options:
  parameters:
    description: 'bladeRF 2.0 micro xA9: peine de 70 a 420 MHz. Sin calibrar, las lineas salen cerca de -3 dBm. En cada contador se carga el valor leido en el analizador y el flujo sube esa linea hasta 0 dBm. La calibracion se guarda en un archivo y se puede importar. SOLO para medir con el analizador: nunca con el cable en RX1'
    generate_options: qt_gui
    id: exp20_a9_peine_calibracion_manual
    output_language: python
    title: 'EXP-20 xA9: peine con calibracion manual por valor medido'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Tasa de muestreo. En esta PC no pasar de
      25e6
    value: 20e6
  states: {}
- name: f_tono
  id: variable
  parameters:
    comment: |-
      Cada portadora lleva dos tonos: en +f_tono y
      en -f_tono
    value: 5e6
  states: {}
- name: ancho_banda
  id: variable
  parameters:
    comment: Filtro analogico de la placa
    value: 18e6
  states: {}
- name: ganancia_de_lectura
  id: variable
  parameters:
    comment: |-
      Ganancia de TX con la que se leen en el
      analizador los valores que se cargan en los
      contadores
    value: '45'
  states: {}
- name: amp_base
  id: variable
  parameters:
    comment: |-
      Amplitud de cada tono sin compensar: deja
      las lineas unos 3 dB por debajo del nivel
      calibrado
    value: '0.25'
  states: {}
- name: amp_max
  id: variable
  parameters:
    comment: |-
      Amplitud maxima de un tono. La suma de los
      dos no debe pasar de 0.95
    value: '0.47'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: f_primera
  id: variable
  parameters:
    comment: |-
      Primera portadora. Sus lineas salen en 70 y
      80 MHz
    value: 75e6
  states: {}
- name: paso_port
  id: variable
  parameters:
    comment: Separacion entre portadoras
    value: 20e6
  states: {}
- name: n_port
  id: variable
  parameters:
    comment: |-
      Cantidad de portadoras: 18 dan 36 lineas, de
      70 a 420 MHz
    value: '18'
  states: {}
- name: permanencia
  id: variable
  parameters:
    comment: |-
      Segundos en cada portadora. Tiene que ser
      mayor que un barrido del analizador
    value: '2.0'
  states: {}
- name: archivo
  id: variable
  parameters:
    comment: |-
      Archivo donde se guarda la calibracion, en
      la carpeta del flujo
    value: '''calibracion_peine.txt'''
  states: {}
- name: estado_archivo
  id: variable
  parameters:
    comment: |-
      Texto sobre el archivo de calibracion. Lo
      cambian los botones
    value: '''hay una guardada, sin importar'' if os.path.exists(archivo) else ''todavia no hay ninguna guardada'''
  states: {}
- name: lista_de_pasos
  id: variable
  parameters:
    comment: 'Los pasos del barrido: 0, 1, 2, ...'
    value: list(range(100000))
  states: {}
- name: paso
  id: variable_function_probe
  parameters:
    block_id: lista_de_pasos
    comment: |-
      Cada 'permanencia' segundos saca el primer
      numero de la lista: es el paso actual
    function_args: '0'
    function_name: pop
    poll_rate: 1.0 / permanencia
    value: '-1'
  states: {}
- name: pasos_por_pasada
  id: variable
  parameters:
    comment: |-
      Recorriendo por nivel se agrega un paso en
      silencio al final de cada pasada
    value: n_port + 1 if orden_recorrido == 1 else n_port
  states: {}
- name: posicion
  id: variable
  parameters:
    comment: Lugar dentro de la pasada, desde 0
    value: max(paso, 0) % pasos_por_pasada
  states: {}
- name: pasada
  id: variable
  parameters:
    comment: Cuantas veces se recorrio el peine
    value: max(paso, 0) // pasos_por_pasada + 1
  states: {}
- name: orden
  id: variable
  parameters:
    comment: |-
      En que orden se visitan las portadoras: por
      frecuencia, o de la menos compensada a la
      mas compensada
    value: 'sorted(range(n_port), key=lambda p: comp[2 * p] + comp[2 * p + 1]) if orden_recorrido == 1 else list(range(n_port))'
  states: {}
- name: indice
  id: variable
  parameters:
    comment: |-
      Portadora actual, de 0 a n_port - 1. El
      valor n_port es el paso en silencio del
      final de la pasada
    value: orden[posicion] if posicion < n_port else n_port
  states: {}
- name: entre_pasadas
  id: variable
  parameters:
    comment: 1 durante el paso en silencio
    value: 1 if indice >= n_port else 0
  states: {}
- name: indice_freq
  id: variable
  parameters:
    comment: |-
      Durante el paso en silencio la placa se
      queda en la ultima portadora
    value: orden[n_port - 1] if indice >= n_port else indice
  states: {}
- name: freq
  id: variable
  parameters:
    comment: Frecuencia de la portadora actual
    value: f_primera + paso_port * indice_freq
  states: {}
- name: pausa
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 1,0,1,3
    label: 'PAUSA: la salida queda en silencio. Destildar para transmitir'
    type: int
    'true': '1'
    'false': '0'
    value: '1'
  states: {}
- name: orden_recorrido
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,6,1,3
    label: Orden de recorrido
    labels: '[''Por frecuencia'', ''De menor a mayor nivel (evita el efecto del retardo)'']'
    options: '[0, 1]'
    num_opts: '0'
    type: int
    value: '0'
  states: {}
- name: ganancia
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Tres puntos: se calibra en el mas bajo y se
      sube de a 10 dB. La compensacion es la misma
      en los tres
    gui_hint: 1,3,1,3
    label: Ganancia de TX
    labels: '[''45 dB: para leer y calibrar (lineas en -20 dBm)'', ''55 dB: lineas en -10 dBm'', ''65 dB: lineas en 0 dBm'']'
    options: '[45, 55, 65]'
    num_opts: '0'
    type: int
    value: '45'
  states: {}
- name: boton_guardar
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 4,0,1,2
    label: Guardar calibracion
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: boton_importar
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 4,2,1,2
    label: Importar calibracion previa
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: medidos
  id: variable
  parameters:
    comment: |-
      Valor leido en el analizador para cada
      linea, en dBm. 0 significa sin dato
    value: '[m_70, m_80, m_90, m_100, m_110, m_120, m_130, m_140, m_150, m_160, m_170, m_180, m_190, m_200, m_210, m_220, m_230, m_240, m_250, m_260, m_270, m_280, m_290, m_300, m_310, m_320, m_330, m_340, m_350, m_360, m_370, m_380, m_390, m_400, m_410, m_420]'
  states: {}
- name: comp
  id: variable
  parameters:
    comment: |-
      Compensacion de cada linea, en dB: lo que le
      falta para el nivel calibrado (0 dBm con
      ganancia 65, -20 dBm con 45). Sin dato, no
      compensa
    value: '[(0.0 if leido == 0 else (ganancia_de_lectura - 65) - leido) for leido in medidos]'
  states: {}
- name: amp_tabla
  id: variable
  parameters:
    comment: |-
      Amplitud de cada tono ya compensada, con
      tope en amp_max. Los dos ceros del final son
      el paso en silencio
    value: '[min(amp_base * 10 ** (db / 20.0), amp_max) for db in comp] + [0.0, 0.0]'
  states: {}
- name: sin_margen
  id: variable
  parameters:
    comment: |-
      Lineas que piden mas compensacion de la que
      hay
    value: sum(1 for db in comp if amp_base * 10 ** (db / 20.0) > amp_max)
  states: {}
- name: cargadas
  id: variable
  parameters:
    comment: Lineas que ya tienen un valor cargado
    value: sum(1 for leido in medidos if leido != 0)
  states: {}
- name: emite
  id: variable
  parameters:
    comment: |-
      1 cuando el flujo esta transmitiendo (ni en
      pausa ni arrancando)
    value: 1 if (pausa == 0 and paso >= 0) else 0
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: |-
      Ganancia que recibe la placa: en pausa baja
      al minimo
    value: ganancia if pausa == 0 else 0
  states: {}
- name: amp_inf_tx
  id: variable
  parameters:
    comment: Amplitud del tono inferior de esta portadora
    value: amp_tabla[2 * indice] if emite == 1 else 0
  states: {}
- name: amp_sup_tx
  id: variable
  parameters:
    comment: Amplitud del tono superior de esta portadora
    value: amp_tabla[2 * indice + 1] if emite == 1 else 0
  states: {}
- name: etapa
  id: variable
  parameters:
    comment: Texto de la etapa actual
    value: '''PAUSA (sin emitir)'' if pausa == 1 else (''INICIACION'' if paso < 0 else (''SILENCIO ENTRE PASADAS'' if entre_pasadas == 1 else ''TRANSMISION, pasada %d'' % pasada))'
  states: {}
- name: et_etapa
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:15pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,0,1,3
    label: '<span style=''font-size:15pt''>Etapa: </span>'
    type: string
    value: etapa
  states: {}
- name: et_portadora
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:15pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,3,1,3
    label: '<span style=''font-size:15pt''>Portadora: </span>'
    type: string
    value: '''%.0f MHz (paso %d de %d)'' % (freq / 1e6, posicion + 1, pasos_por_pasada)'
  states: {}
- name: et_lineas
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:15pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,6,1,3
    label: '<span style=''font-size:15pt''>Lineas: </span>'
    type: string
    value: '''%.0f y %.0f MHz'' % ((freq - f_tono) / 1e6, (freq + f_tono) / 1e6)'
  states: {}
- name: et_tiempos
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 2,6,1,3
    label: '<span style=''font-size:11pt''>Pasada completa: </span>'
    type: string
    value: '''%.0f s (%.1f s por portadora)'' % (permanencia * pasos_por_pasada, permanencia)'
  states: {}
- name: et_comp
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 2,3,1,3
    label: '<span style=''font-size:11pt''>Compensacion de estas dos lineas: </span>'
    type: string
    value: '''%+.1f y %+.1f dB'' % (comp[2 * indice_freq], comp[2 * indice_freq + 1])'
  states: {}
- name: et_cargadas
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 3,0,1,3
    label: '<span style=''font-size:11pt''>Lineas con valor cargado: </span>'
    type: string
    value: '''%d de %d'' % (cargadas, 2 * n_port)'
  states: {}
- name: et_margen
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 3,3,1,3
    label: '<span style=''font-size:11pt''>Lineas que piden mas de lo que hay: </span>'
    type: int
    value: sin_margen
  states: {}
- name: et_archivo
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 4,4,1,5
    label: '<span style=''font-size:11pt''>Calibracion en archivo: </span>'
    type: string
    value: estado_archivo
  states: {}
- name: et_titulo
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''>" + str(x) + "</span>"'
    gui_hint: 5,0,1,9
    label: '<span style=''font-size:11pt''><b>Valor leido en el analizador para cada linea (MHz), en dBm: </b></span>'
    type: string
    value: '''con MAX HOLD, con la ganancia de TX en %d dB y con ese contador en 0'' % ganancia_de_lectura'
  states: {}
- name: et_nivel
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 2,0,1,3
    label: '<span style=''font-size:11pt''>Con esta ganancia: </span>'
    type: string
    value: '''sin calibrar unos %d dBm, calibradas %d dBm'' % (ganancia - 68, ganancia - 65)'
  states: {}
- name: tono_superior
  id: analog_sig_source_x
  parameters:
    comment: Sale en portadora + 5 MHz
    amp: amp_sup_tx
    freq: f_tono
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: tono_inferior
  id: analog_sig_source_x
  parameters:
    comment: Sale en portadora - 5 MHz
    amp: amp_inf_tx
    freq: '-f_tono'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: suma
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=321e0fa5875945d99b11070bb0a76d31
    bb_gain0: '0'
    bw0: ancho_banda
    comment: |-
      bladeRF 2.0 micro xA9, salida TX1. Solo
      hacia el analizador
    freq0: freq
    gain0: tx_gain
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: linea_de_punto
  id: variable
  parameters:
    comment: |-
      El grafico tiene 256 puntos, 7 por linea: a
      que linea (0 a 35) corresponde cada punto
    value: '[min(j // 7, 2 * n_port - 1) for j in range(256)]'
  states: {}
- name: curva_comp
  id: variable
  parameters:
    comment: Compensacion de cada linea, punto por punto
    value: '[comp[k] for k in linea_de_punto]'
  states: {}
- name: curva_actual
  id: variable
  parameters:
    comment: Marca las dos lineas que salen ahora
    value: '[(comp[k] if (k // 2 == indice and emite == 1) else -2) for k in linea_de_punto]'
  states: {}
- name: datos_comp
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: curva_comp
    vlen: '256'
  states: {}
- name: datos_actual
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: curva_actual
    vlen: '256'
  states: {}
- name: ritmo_grafico
  id: blocks_throttle2
  parameters:
    comment: Solo marca el ritmo del grafico
    limit: time
    maximum: '0.01'
    samples_per_second: '2000'
    type: float
    vlen: '256'
  states: {}
- name: grafico
  id: qtgui_vector_sink_f
  parameters:
    name: '"Compensacion aplicada a cada linea"'
    vlen: '256'
    x_start: (f_primera - f_tono) / 1e6 - 5
    x_step: 10.0 / 7
    x_axis_label: '"Frecuencia de la linea"'
    y_axis_label: '"Compensacion"'
    x_units: '"MHz"'
    y_units: '"dB"'
    grid: 'True'
    ymin: '-2'
    ymax: '7'
    nconnections: '2'
    gui_hint: 10,0,1,9
    label1: '"Compensacion de cada linea"'
    width1: '2'
    label2: '"Lineas que salen ahora"'
    width2: '3'
  states: {}
- name: m_70
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,1
    label: <div align='right'>70:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_80
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,1,1,1
    label: <div align='right'>80:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_90
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,2,1,1
    label: <div align='right'>90:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_100
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,3,1,1
    label: <div align='right'>100:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_110
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,4,1,1
    label: <div align='right'>110:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_120
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,5,1,1
    label: <div align='right'>120:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_130
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,6,1,1
    label: <div align='right'>130:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_140
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,7,1,1
    label: <div align='right'>140:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_150
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,8,1,1
    label: <div align='right'>150:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_160
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,1
    label: <div align='right'>160:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_170
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,1,1,1
    label: <div align='right'>170:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_180
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,2,1,1
    label: <div align='right'>180:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_190
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,3,1,1
    label: <div align='right'>190:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_200
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,4,1,1
    label: <div align='right'>200:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_210
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,5,1,1
    label: <div align='right'>210:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_220
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,6,1,1
    label: <div align='right'>220:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_230
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,7,1,1
    label: <div align='right'>230:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_240
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,8,1,1
    label: <div align='right'>240:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_250
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,0,1,1
    label: <div align='right'>250:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_260
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,1,1,1
    label: <div align='right'>260:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_270
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,2,1,1
    label: <div align='right'>270:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_280
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,3,1,1
    label: <div align='right'>280:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_290
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,4,1,1
    label: <div align='right'>290:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_300
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,5,1,1
    label: <div align='right'>300:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_310
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,6,1,1
    label: <div align='right'>310:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_320
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,7,1,1
    label: <div align='right'>320:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_330
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,8,1,1
    label: <div align='right'>330:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_340
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,0,1,1
    label: <div align='right'>340:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_350
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,1,1,1
    label: <div align='right'>350:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_360
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,2,1,1
    label: <div align='right'>360:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_370
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,3,1,1
    label: <div align='right'>370:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_380
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,4,1,1
    label: <div align='right'>380:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_390
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,5,1,1
    label: <div align='right'>390:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_400
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,6,1,1
    label: <div align='right'>400:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_410
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,7,1,1
    label: <div align='right'>410:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_420
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,8,1,1
    label: <div align='right'>420:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: guardar_e_importar
  id: snippet
  parameters:
    comment: |-
      Guarda la calibracion en un archivo y la
      vuelve a cargar
    section: main_after_init
    code: |
      # ============================================================================
      # GUARDAR E IMPORTAR LA CALIBRACION
      # Es el unico codigo Python del flujo. Hace falta porque los bloques no saben
      # escribir ni leer un archivo con valores.
      #   Boton "Guardar calibracion": escribe en un archivo de texto los 36 valores
      #   cargados en la ventana, uno por renglon, junto a su frecuencia.
      #   Boton "Importar calibracion previa": lee ese archivo y pone cada valor en
      #   su contador.
      # ============================================================================
      import os
      import time

      # Los 36 contadores de la ventana, en orden de frecuencia (70, 80, ... 420 MHz).
      # d_widget es la casilla con flechas que se ve en pantalla.
      contadores = [
          self._m_70_win.d_widget, self._m_80_win.d_widget, self._m_90_win.d_widget,
          self._m_100_win.d_widget, self._m_110_win.d_widget, self._m_120_win.d_widget,
          self._m_130_win.d_widget, self._m_140_win.d_widget, self._m_150_win.d_widget,
          self._m_160_win.d_widget, self._m_170_win.d_widget, self._m_180_win.d_widget,
          self._m_190_win.d_widget, self._m_200_win.d_widget, self._m_210_win.d_widget,
          self._m_220_win.d_widget, self._m_230_win.d_widget, self._m_240_win.d_widget,
          self._m_250_win.d_widget, self._m_260_win.d_widget, self._m_270_win.d_widget,
          self._m_280_win.d_widget, self._m_290_win.d_widget, self._m_300_win.d_widget,
          self._m_310_win.d_widget, self._m_320_win.d_widget, self._m_330_win.d_widget,
          self._m_340_win.d_widget, self._m_350_win.d_widget, self._m_360_win.d_widget,
          self._m_370_win.d_widget, self._m_380_win.d_widget, self._m_390_win.d_widget,
          self._m_400_win.d_widget, self._m_410_win.d_widget, self._m_420_win.d_widget,
      ]


      def guardar():
          valores = self.get_medidos()                 # los 36 valores de la ventana
          try:
              archivo = open(self.get_archivo(), 'w')
              # primer renglon: cuando se guardo y con que ganancia se leyeron los valores
              archivo.write('# guardada el ' + time.strftime('%d-%m-%Y %H:%M') +
                            ', valores leidos con ganancia %d dB\n' % self.get_ganancia_de_lectura())
              for k in range(len(valores)):
                  frecuencia = 70 + 10 * k
                  archivo.write('%d %.1f\n' % (frecuencia, valores[k]))
              archivo.close()
          except Exception:
              self.set_estado_archivo('NO se pudo guardar')
              return
          self.set_estado_archivo('guardada a las ' + time.strftime('%H:%M:%S'))


      def importar():
          if not os.path.exists(self.get_archivo()):
              self.set_estado_archivo('no hay ninguna calibracion guardada')
              return
          try:
              archivo = open(self.get_archivo())
              renglones = archivo.readlines()
              archivo.close()
              if renglones[0].startswith('#'):
                  renglones = renglones[1:]            # se saltea el renglon de encabezado
              valores = []
              for k in range(len(contadores)):
                  partes = renglones[k].split()        # cada renglon: frecuencia y valor
                  valores.append(float(partes[1]))
          except Exception:
              self.set_estado_archivo('el archivo no se pudo leer: no se importo nada')
              return
          for k in range(len(contadores)):
              contadores[k].setValue(valores[k])       # al cambiar el contador, el flujo se actualiza solo
          self.set_estado_archivo('importada a las ' + time.strftime('%H:%M:%S'))


      # GNU Radio llama a set_boton_guardar(1) cuando se aprieta el boton y a
      # set_boton_guardar(0) cuando se suelta. Aca se define que hace esa llamada.
      def al_tocar_guardar(valor):
          if valor == 1:
              guardar()


      def al_tocar_importar(valor):
          if valor == 1:
              importar()


      self.set_boton_guardar = al_tocar_guardar
      self.set_boton_importar = al_tocar_importar
  states: {}

connections:
- [tono_superior, '0', suma, '0']
- [tono_inferior, '0', suma, '1']
- [suma, '0', osmosdr_sink_0, '0']
- [datos_comp, '0', ritmo_grafico, '0']
- [ritmo_grafico, '0', grafico, '0']
- [datos_actual, '0', grafico, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
