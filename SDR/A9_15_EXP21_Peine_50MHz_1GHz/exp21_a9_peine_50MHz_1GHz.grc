options:
  parameters:
    description: 'bladeRF 2.0 micro xA9: peine de 50 a 1000 MHz, 96 lineas cada 10 MHz. Sin calibrar, las lineas salen unos 3 dB por debajo del nivel calibrado. El boton Generar calibracion lee la captura del analizador, carga el valor de cada linea y el flujo la sube hasta el nivel calibrado. La calibracion se guarda en un archivo y se puede importar. SOLO para medir con el analizador: nunca con el cable en RX1'
    generate_options: qt_gui
    id: exp21_a9_peine_50MHz_1GHz
    output_language: python
    title: 'EXP-21 xA9: peine de 50 MHz a 1 GHz con calibracion desde una captura'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Tasa de muestreo. En esta PC no pasar de
      25e6
    value: 20e6
  states: {}
- name: f_tono
  id: variable
  parameters:
    comment: |-
      Cada portadora lleva dos tonos: en +f_tono y
      en -f_tono
    value: 5e6
  states: {}
- name: ancho_banda
  id: variable
  parameters:
    comment: Filtro analogico de la placa
    value: 18e6
  states: {}
- name: ganancia_de_lectura
  id: variable
  parameters:
    comment: |-
      Ganancia de TX a la que estan referidos los
      valores de los contadores y del archivo de
      calibracion
    value: '45'
  states: {}
- name: amp_base
  id: variable
  parameters:
    comment: |-
      Amplitud de cada tono sin compensar: deja
      las lineas unos 3 dB por debajo del nivel
      calibrado
    value: '0.25'
  states: {}
- name: amp_max
  id: variable
  parameters:
    comment: |-
      Amplitud maxima de un tono. La suma de los
      dos no debe pasar de 0.95
    value: '0.47'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: f_primera
  id: variable
  parameters:
    comment: |-
      Primera portadora. Sus lineas salen en 50 y
      60 MHz
    value: 55e6
  states: {}
- name: paso_port
  id: variable
  parameters:
    comment: Separacion entre portadoras
    value: 20e6
  states: {}
- name: n_port
  id: variable
  parameters:
    comment: |-
      Cantidad de portadoras: 48 dan 96 lineas, de
      50 a 1000 MHz
    value: '48'
  states: {}
- name: permanencia
  id: variable
  parameters:
    comment: |-
      Segundos en cada portadora. Tiene que ser
      mayor que un barrido del analizador (2,8 s
      en la tinySA para toda la banda)
    value: '6.0'
  states: {}
- name: archivo
  id: variable
  parameters:
    comment: |-
      Archivo donde se guarda la calibracion, en
      la carpeta del flujo
    value: '''calibracion_peine.txt'''
  states: {}
- name: estado_archivo
  id: variable
  parameters:
    comment: |-
      Texto sobre el archivo de calibracion. Lo
      cambian los botones
    value: '''hay una guardada, sin importar'' if os.path.exists(archivo) else ''todavia no hay ninguna guardada'''
  states: {}
- name: lista_de_pasos
  id: variable
  parameters:
    comment: 'Los pasos del barrido: 0, 1, 2, ...'
    value: list(range(100000))
  states: {}
- name: paso
  id: variable_function_probe
  parameters:
    block_id: lista_de_pasos
    comment: |-
      Cada 'permanencia' segundos saca el primer
      numero de la lista: es el paso actual
    function_args: '0'
    function_name: pop
    poll_rate: 1.0 / permanencia
    value: '-1'
  states: {}
- name: pasos_por_pasada
  id: variable
  parameters:
    comment: |-
      Recorriendo por nivel se agrega un paso en
      silencio al final de cada pasada
    value: n_port + 1 if orden_recorrido == 1 else n_port
  states: {}
- name: posicion
  id: variable
  parameters:
    comment: Lugar dentro de la pasada, desde 0
    value: max(paso, 0) % pasos_por_pasada
  states: {}
- name: pasada
  id: variable
  parameters:
    comment: Cuantas veces se recorrio el peine
    value: max(paso, 0) // pasos_por_pasada + 1
  states: {}
- name: orden
  id: variable
  parameters:
    comment: |-
      En que orden se visitan las portadoras: por
      frecuencia, o de la menos compensada a la
      mas compensada
    value: 'sorted(range(n_port), key=lambda p: comp[2 * p] + comp[2 * p + 1]) if orden_recorrido == 1 else list(range(n_port))'
  states: {}
- name: indice
  id: variable
  parameters:
    comment: |-
      Portadora actual, de 0 a n_port - 1. El
      valor n_port es el paso en silencio del
      final de la pasada
    value: orden[posicion] if posicion < n_port else n_port
  states: {}
- name: entre_pasadas
  id: variable
  parameters:
    comment: 1 durante el paso en silencio
    value: 1 if indice >= n_port else 0
  states: {}
- name: indice_freq
  id: variable
  parameters:
    comment: |-
      Durante el paso en silencio la placa se
      queda en la ultima portadora
    value: orden[n_port - 1] if indice >= n_port else indice
  states: {}
- name: freq
  id: variable
  parameters:
    comment: Frecuencia de la portadora actual
    value: f_primera + paso_port * indice_freq
  states: {}
- name: pausa
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 1,0,1,4
    label: 'PAUSA: la salida queda en silencio. Destildar para transmitir'
    type: int
    'true': '1'
    'false': '0'
    value: '1'
  states: {}
- name: orden_recorrido
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,8,1,4
    label: Orden de recorrido
    labels: '[''Por frecuencia'', ''De menor a mayor nivel (evita el efecto del retardo)'']'
    options: '[0, 1]'
    num_opts: '0'
    type: int
    value: '0'
  states: {}
- name: ganancia
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Tres puntos, de a 10 dB. La compensacion es
      la misma en los tres
    gui_hint: 1,4,1,4
    label: Ganancia de TX
    labels: '[''45 dB: lineas en -20 dBm'', ''55 dB: lineas en -10 dBm'', ''65 dB: lineas en 0 dBm'']'
    options: '[45, 55, 65]'
    num_opts: '0'
    type: int
    value: '45'
  states: {}
- name: boton_generar
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 4,0,1,4
    label: Generar calibracion (desde la captura .csv del analizador)
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: boton_guardar
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 4,4,1,4
    label: Guardar calibracion
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: boton_importar
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 4,8,1,4
    label: Importar calibracion previa
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: medidos
  id: variable
  parameters:
    comment: |-
      Valor leido en el analizador para cada
      linea, en dBm. 0 significa sin dato
    value: '[m_50, m_60, m_70, m_80, m_90, m_100, m_110, m_120, m_130, m_140, m_150, m_160, m_170, m_180, m_190, m_200, m_210, m_220, m_230, m_240, m_250, m_260, m_270, m_280, m_290, m_300, m_310, m_320, m_330, m_340, m_350, m_360, m_370, m_380, m_390, m_400, m_410, m_420, m_430, m_440, m_450, m_460, m_470, m_480, m_490, m_500, m_510, m_520, m_530, m_540, m_550, m_560, m_570, m_580, m_590, m_600, m_610, m_620, m_630, m_640, m_650, m_660, m_670, m_680, m_690, m_700, m_710, m_720, m_730, m_740, m_750, m_760, m_770, m_780, m_790, m_800, m_810, m_820, m_830, m_840, m_850, m_860, m_870, m_880, m_890, m_900, m_910, m_920, m_930, m_940, m_950, m_960, m_970, m_980, m_990, m_1000]'
  states: {}
- name: comp
  id: variable
  parameters:
    comment: |-
      Compensacion de cada linea, en dB: lo que le
      falta para el nivel calibrado (0 dBm con
      ganancia 65, -20 dBm con 45). Sin dato, no
      compensa
    value: '[(0.0 if leido == 0 else (ganancia_de_lectura - 65) - leido) for leido in medidos]'
  states: {}
- name: amp_tabla
  id: variable
  parameters:
    comment: |-
      Amplitud de cada tono ya compensada, con
      tope en amp_max. Los dos ceros del final son
      el paso en silencio
    value: '[min(amp_base * 10 ** (db / 20.0), amp_max) for db in comp] + [0.0, 0.0]'
  states: {}
- name: sin_margen
  id: variable
  parameters:
    comment: |-
      Lineas que piden mas compensacion de la que
      hay
    value: sum(1 for db in comp if amp_base * 10 ** (db / 20.0) > amp_max)
  states: {}
- name: cargadas
  id: variable
  parameters:
    comment: Lineas que ya tienen un valor cargado
    value: sum(1 for leido in medidos if leido != 0)
  states: {}
- name: emite
  id: variable
  parameters:
    comment: |-
      1 cuando el flujo esta transmitiendo (ni en
      pausa ni arrancando)
    value: 1 if (pausa == 0 and paso >= 0) else 0
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: |-
      Ganancia que recibe la placa: en pausa baja
      al minimo
    value: ganancia if pausa == 0 else 0
  states: {}
- name: amp_inf_tx
  id: variable
  parameters:
    comment: Amplitud del tono inferior de esta portadora
    value: amp_tabla[2 * indice] if emite == 1 else 0
  states: {}
- name: amp_sup_tx
  id: variable
  parameters:
    comment: Amplitud del tono superior de esta portadora
    value: amp_tabla[2 * indice + 1] if emite == 1 else 0
  states: {}
- name: nivel_sin_calibrar
  id: variable
  parameters:
    comment: |-
      Nivel aproximado de una linea sin calibrar,
      en dBm, segun la ganancia elegida (medido en
      el EXP-20)
    value: ganancia - 68
  states: {}
- name: etapa
  id: variable
  parameters:
    comment: Texto de la etapa actual
    value: '''PAUSA (sin emitir)'' if pausa == 1 else (''INICIACION'' if paso < 0 else (''SILENCIO ENTRE PASADAS'' if entre_pasadas == 1 else ''TRANSMISION, pasada %d'' % pasada))'
  states: {}
- name: et_etapa
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:15pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,0,1,4
    label: '<span style=''font-size:15pt''>Etapa: </span>'
    type: string
    value: etapa
  states: {}
- name: et_portadora
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:15pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,4,1,4
    label: '<span style=''font-size:15pt''>Portadora: </span>'
    type: string
    value: '''%.0f MHz (paso %d de %d)'' % (freq / 1e6, posicion + 1, pasos_por_pasada)'
  states: {}
- name: et_lineas
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:15pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,8,1,4
    label: '<span style=''font-size:15pt''>Lineas: </span>'
    type: string
    value: '''%.0f y %.0f MHz'' % ((freq - f_tono) / 1e6, (freq + f_tono) / 1e6)'
  states: {}
- name: et_tiempos
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 2,8,1,4
    label: '<span style=''font-size:11pt''>Pasada completa: </span>'
    type: string
    value: '''%d min %02d s (%.0f s por portadora)'' % (permanencia * pasos_por_pasada // 60, permanencia * pasos_por_pasada % 60, permanencia)'
  states: {}
- name: et_comp
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 2,4,1,4
    label: '<span style=''font-size:11pt''>Compensacion de estas dos lineas: </span>'
    type: string
    value: '''%+.1f y %+.1f dB'' % (comp[2 * indice_freq], comp[2 * indice_freq + 1])'
  states: {}
- name: et_cargadas
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 3,0,1,4
    label: '<span style=''font-size:11pt''>Lineas con valor cargado: </span>'
    type: string
    value: '''%d de %d'' % (cargadas, 2 * n_port)'
  states: {}
- name: et_margen
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 3,4,1,4
    label: '<span style=''font-size:11pt''>Lineas que piden mas de lo que hay: </span>'
    type: int
    value: sin_margen
  states: {}
- name: et_archivo
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 5,0,1,12
    label: '<span style=''font-size:11pt''>Calibracion en archivo: </span>'
    type: string
    value: estado_archivo
  states: {}
- name: et_titulo
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''>" + str(x) + "</span>"'
    gui_hint: 6,0,1,12
    label: '<span style=''font-size:11pt''><b>Valor de cada linea (MHz) con el peine sin calibrar, en dBm: </b></span>'
    type: string
    value: '''referido a la ganancia de %d dB. Lo carga Generar calibracion; tambien se puede corregir a mano'' % ganancia_de_lectura'
  states: {}
- name: et_nivel
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 2,0,1,4
    label: '<span style=''font-size:11pt''>Con esta ganancia: </span>'
    type: string
    value: '''sin calibrar unos %d dBm, calibradas %d dBm'' % (nivel_sin_calibrar, ganancia - 65)'
  states: {}
- name: tono_superior
  id: analog_sig_source_x
  parameters:
    comment: Sale en portadora + 5 MHz
    amp: amp_sup_tx
    freq: f_tono
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: tono_inferior
  id: analog_sig_source_x
  parameters:
    comment: Sale en portadora - 5 MHz
    amp: amp_inf_tx
    freq: '-f_tono'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: suma
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=321e0fa5875945d99b11070bb0a76d31
    bb_gain0: '0'
    bw0: ancho_banda
    comment: |-
      bladeRF 2.0 micro xA9, salida TX1. Solo
      hacia el analizador
    freq0: freq
    gain0: tx_gain
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: linea_de_punto
  id: variable
  parameters:
    comment: |-
      El grafico tiene 512 puntos repartidos entre
      las lineas: a que linea (0 a 95) corresponde
      cada punto
    value: '[j * 2 * n_port // 512 for j in range(512)]'
  states: {}
- name: curva_comp
  id: variable
  parameters:
    comment: Compensacion de cada linea, punto por punto
    value: '[comp[k] for k in linea_de_punto]'
  states: {}
- name: curva_actual
  id: variable
  parameters:
    comment: Marca las dos lineas que salen ahora
    value: '[(comp[k] if (k // 2 == indice and emite == 1) else -2) for k in linea_de_punto]'
  states: {}
- name: datos_comp
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: curva_comp
    vlen: '512'
  states: {}
- name: datos_actual
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: curva_actual
    vlen: '512'
  states: {}
- name: ritmo_grafico
  id: blocks_throttle2
  parameters:
    comment: Solo marca el ritmo del grafico
    limit: time
    maximum: '0.01'
    samples_per_second: '2000'
    type: float
    vlen: '512'
  states: {}
- name: grafico
  id: qtgui_vector_sink_f
  parameters:
    name: '"Compensacion aplicada a cada linea"'
    vlen: '512'
    x_start: (f_primera - f_tono) / 1e6 - 5
    x_step: 2 * n_port * 10.0 / 512
    x_axis_label: '"Frecuencia de la linea"'
    y_axis_label: '"Compensacion"'
    x_units: '"MHz"'
    y_units: '"dB"'
    grid: 'True'
    ymin: '-2'
    ymax: '7'
    nconnections: '2'
    gui_hint: 15,0,1,12
    label1: '"Compensacion de cada linea"'
    width1: '2'
    label2: '"Lineas que salen ahora"'
    width2: '3'
  states: {}
- name: m_50
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,1
    label: <div align='right'>50:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_60
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,1,1,1
    label: <div align='right'>60:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_70
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,2,1,1
    label: <div align='right'>70:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_80
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,3,1,1
    label: <div align='right'>80:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_90
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,4,1,1
    label: <div align='right'>90:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_100
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,5,1,1
    label: <div align='right'>100:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_110
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,6,1,1
    label: <div align='right'>110:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_120
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,7,1,1
    label: <div align='right'>120:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_130
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,8,1,1
    label: <div align='right'>130:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_140
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,9,1,1
    label: <div align='right'>140:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_150
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,10,1,1
    label: <div align='right'>150:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_160
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,11,1,1
    label: <div align='right'>160:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_170
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,0,1,1
    label: <div align='right'>170:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_180
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,1,1,1
    label: <div align='right'>180:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_190
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,2,1,1
    label: <div align='right'>190:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_200
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,3,1,1
    label: <div align='right'>200:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_210
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,4,1,1
    label: <div align='right'>210:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_220
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,5,1,1
    label: <div align='right'>220:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_230
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,6,1,1
    label: <div align='right'>230:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_240
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,7,1,1
    label: <div align='right'>240:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_250
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,8,1,1
    label: <div align='right'>250:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_260
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,9,1,1
    label: <div align='right'>260:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_270
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,10,1,1
    label: <div align='right'>270:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_280
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,11,1,1
    label: <div align='right'>280:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_290
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,0,1,1
    label: <div align='right'>290:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_300
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,1,1,1
    label: <div align='right'>300:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_310
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,2,1,1
    label: <div align='right'>310:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_320
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,3,1,1
    label: <div align='right'>320:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_330
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,4,1,1
    label: <div align='right'>330:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_340
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,5,1,1
    label: <div align='right'>340:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_350
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,6,1,1
    label: <div align='right'>350:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_360
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,7,1,1
    label: <div align='right'>360:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_370
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,8,1,1
    label: <div align='right'>370:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_380
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,9,1,1
    label: <div align='right'>380:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_390
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,10,1,1
    label: <div align='right'>390:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_400
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,11,1,1
    label: <div align='right'>400:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_410
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,0,1,1
    label: <div align='right'>410:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_420
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,1,1,1
    label: <div align='right'>420:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_430
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,2,1,1
    label: <div align='right'>430:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_440
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,3,1,1
    label: <div align='right'>440:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_450
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,4,1,1
    label: <div align='right'>450:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_460
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,5,1,1
    label: <div align='right'>460:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_470
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,6,1,1
    label: <div align='right'>470:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_480
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,7,1,1
    label: <div align='right'>480:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_490
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,8,1,1
    label: <div align='right'>490:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_500
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,9,1,1
    label: <div align='right'>500:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_510
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,10,1,1
    label: <div align='right'>510:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_520
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,11,1,1
    label: <div align='right'>520:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_530
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,0,1,1
    label: <div align='right'>530:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_540
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,1,1,1
    label: <div align='right'>540:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_550
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,2,1,1
    label: <div align='right'>550:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_560
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,3,1,1
    label: <div align='right'>560:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_570
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,4,1,1
    label: <div align='right'>570:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_580
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,5,1,1
    label: <div align='right'>580:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_590
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,6,1,1
    label: <div align='right'>590:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_600
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,7,1,1
    label: <div align='right'>600:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_610
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,8,1,1
    label: <div align='right'>610:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_620
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,9,1,1
    label: <div align='right'>620:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_630
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,10,1,1
    label: <div align='right'>630:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_640
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,11,1,1
    label: <div align='right'>640:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_650
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,0,1,1
    label: <div align='right'>650:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_660
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,1,1,1
    label: <div align='right'>660:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_670
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,2,1,1
    label: <div align='right'>670:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_680
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,3,1,1
    label: <div align='right'>680:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_690
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,4,1,1
    label: <div align='right'>690:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_700
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,5,1,1
    label: <div align='right'>700:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_710
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,6,1,1
    label: <div align='right'>710:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_720
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,7,1,1
    label: <div align='right'>720:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_730
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,8,1,1
    label: <div align='right'>730:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_740
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,9,1,1
    label: <div align='right'>740:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_750
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,10,1,1
    label: <div align='right'>750:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_760
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,11,1,1
    label: <div align='right'>760:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_770
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,0,1,1
    label: <div align='right'>770:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_780
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,1,1,1
    label: <div align='right'>780:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_790
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,2,1,1
    label: <div align='right'>790:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_800
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,3,1,1
    label: <div align='right'>800:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_810
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,4,1,1
    label: <div align='right'>810:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_820
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,5,1,1
    label: <div align='right'>820:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_830
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,6,1,1
    label: <div align='right'>830:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_840
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,7,1,1
    label: <div align='right'>840:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_850
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,8,1,1
    label: <div align='right'>850:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_860
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,9,1,1
    label: <div align='right'>860:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_870
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,10,1,1
    label: <div align='right'>870:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_880
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,11,1,1
    label: <div align='right'>880:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_890
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,0,1,1
    label: <div align='right'>890:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_900
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,1,1,1
    label: <div align='right'>900:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_910
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,2,1,1
    label: <div align='right'>910:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_920
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,3,1,1
    label: <div align='right'>920:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_930
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,4,1,1
    label: <div align='right'>930:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_940
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,5,1,1
    label: <div align='right'>940:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_950
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,6,1,1
    label: <div align='right'>950:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_960
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,7,1,1
    label: <div align='right'>960:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_970
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,8,1,1
    label: <div align='right'>970:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_980
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,9,1,1
    label: <div align='right'>980:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_990
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,10,1,1
    label: <div align='right'>990:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_1000
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,11,1,1
    label: <div align='right'>1000:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: archivos_de_calibracion
  id: snippet
  parameters:
    comment: |-
      Genera la calibracion desde una captura, la
      guarda en un archivo y la vuelve a cargar
    section: main_after_init
    code: |
      # ============================================================================
      # ARCHIVOS DE CALIBRACION
      # Es el unico codigo Python del flujo. Hace falta porque los bloques no saben
      # escribir ni leer archivos.
      #   Boton "Generar calibracion": pide la captura (.csv) que guardo el analizador
      #   con el peine SIN calibrar, busca el pico de cada linea, lo carga en su
      #   contador y guarda el archivo de calibracion.
      #   Boton "Guardar calibracion": escribe en un archivo de texto los 96 valores
      #   cargados en la ventana, uno por renglon, junto a su frecuencia.
      #   Boton "Importar calibracion previa": lee ese archivo y pone cada valor en
      #   su contador.
      # ============================================================================
      import os
      import time

      PRIMERA_LINEA = 50        # MHz
      SEPARACION = 10           # MHz entre una linea y la siguiente
      CERCA = 4                 # MHz: hasta que distancia de una linea se busca su pico

      # Los 96 contadores de la ventana, en orden de frecuencia (50, 60, ... 1000 MHz).
      # d_widget es la casilla con flechas que se ve en pantalla.
      contadores = [
          self._m_50_win.d_widget, self._m_60_win.d_widget, self._m_70_win.d_widget,
          self._m_80_win.d_widget, self._m_90_win.d_widget, self._m_100_win.d_widget,
          self._m_110_win.d_widget, self._m_120_win.d_widget, self._m_130_win.d_widget,
          self._m_140_win.d_widget, self._m_150_win.d_widget, self._m_160_win.d_widget,
          self._m_170_win.d_widget, self._m_180_win.d_widget, self._m_190_win.d_widget,
          self._m_200_win.d_widget, self._m_210_win.d_widget, self._m_220_win.d_widget,
          self._m_230_win.d_widget, self._m_240_win.d_widget, self._m_250_win.d_widget,
          self._m_260_win.d_widget, self._m_270_win.d_widget, self._m_280_win.d_widget,
          self._m_290_win.d_widget, self._m_300_win.d_widget, self._m_310_win.d_widget,
          self._m_320_win.d_widget, self._m_330_win.d_widget, self._m_340_win.d_widget,
          self._m_350_win.d_widget, self._m_360_win.d_widget, self._m_370_win.d_widget,
          self._m_380_win.d_widget, self._m_390_win.d_widget, self._m_400_win.d_widget,
          self._m_410_win.d_widget, self._m_420_win.d_widget, self._m_430_win.d_widget,
          self._m_440_win.d_widget, self._m_450_win.d_widget, self._m_460_win.d_widget,
          self._m_470_win.d_widget, self._m_480_win.d_widget, self._m_490_win.d_widget,
          self._m_500_win.d_widget, self._m_510_win.d_widget, self._m_520_win.d_widget,
          self._m_530_win.d_widget, self._m_540_win.d_widget, self._m_550_win.d_widget,
          self._m_560_win.d_widget, self._m_570_win.d_widget, self._m_580_win.d_widget,
          self._m_590_win.d_widget, self._m_600_win.d_widget, self._m_610_win.d_widget,
          self._m_620_win.d_widget, self._m_630_win.d_widget, self._m_640_win.d_widget,
          self._m_650_win.d_widget, self._m_660_win.d_widget, self._m_670_win.d_widget,
          self._m_680_win.d_widget, self._m_690_win.d_widget, self._m_700_win.d_widget,
          self._m_710_win.d_widget, self._m_720_win.d_widget, self._m_730_win.d_widget,
          self._m_740_win.d_widget, self._m_750_win.d_widget, self._m_760_win.d_widget,
          self._m_770_win.d_widget, self._m_780_win.d_widget, self._m_790_win.d_widget,
          self._m_800_win.d_widget, self._m_810_win.d_widget, self._m_820_win.d_widget,
          self._m_830_win.d_widget, self._m_840_win.d_widget, self._m_850_win.d_widget,
          self._m_860_win.d_widget, self._m_870_win.d_widget, self._m_880_win.d_widget,
          self._m_890_win.d_widget, self._m_900_win.d_widget, self._m_910_win.d_widget,
          self._m_920_win.d_widget, self._m_930_win.d_widget, self._m_940_win.d_widget,
          self._m_950_win.d_widget, self._m_960_win.d_widget, self._m_970_win.d_widget,
          self._m_980_win.d_widget, self._m_990_win.d_widget, self._m_1000_win.d_widget,
      ]


      def guardar():
          valores = self.get_medidos()                 # los 96 valores de la ventana
          try:
              archivo = open(self.get_archivo(), 'w')
              # primer renglon: cuando se guardo y con que ganancia se leyeron los valores
              archivo.write('# guardada el ' + time.strftime('%d-%m-%Y %H:%M') +
                            ', valores leidos con ganancia %d dB\n' % self.get_ganancia_de_lectura())
              for k in range(len(valores)):
                  frecuencia = PRIMERA_LINEA + SEPARACION * k
                  archivo.write('%d %.1f\n' % (frecuencia, valores[k]))
              archivo.close()
          except Exception:
              self.set_estado_archivo('NO se pudo guardar')
              return False
          self.set_estado_archivo('guardada a las ' + time.strftime('%H:%M:%S'))
          return True


      def importar():
          if not os.path.exists(self.get_archivo()):
              self.set_estado_archivo('no hay ninguna calibracion guardada')
              return
          try:
              archivo = open(self.get_archivo())
              renglones = archivo.readlines()
              archivo.close()
              if renglones[0].startswith('#'):
                  renglones = renglones[1:]            # se saltea el renglon de encabezado
              valores = []
              for k in range(len(contadores)):
                  partes = renglones[k].split()        # cada renglon: frecuencia y valor
                  valores.append(float(partes[1]))
          except Exception:
              self.set_estado_archivo('el archivo no se pudo leer: no se importo nada')
              return
          for k in range(len(contadores)):
              contadores[k].setValue(valores[k])       # al cambiar el contador, el flujo se actualiza solo
          self.set_estado_archivo('importada a las ' + time.strftime('%H:%M:%S'))


      def leer_captura(nombre):
          # Lee una captura del analizador: un renglon por punto, con la frecuencia y
          # el nivel separados por una coma. Devuelve dos listas: MHz y dBm.
          frecuencias = []
          niveles = []
          archivo = open(nombre)
          for renglon in archivo:
              partes = renglon.replace(';', ',').split(',')
              try:
                  frecuencia = float(partes[0])
                  nivel = float(partes[1])
              except Exception:
                  continue                             # renglon de titulo o vacio: se saltea
              if frecuencia > 100000:
                  frecuencia = frecuencia / 1e6        # estaba en Hz: se pasa a MHz
              frecuencias.append(frecuencia)
              niveles.append(nivel)
          archivo.close()
          return frecuencias, niveles


      def pico_de_la_linea(frecuencias, niveles, linea):
          # Devuelve el nivel mas alto que hay en la captura a menos de 4 MHz de la
          # linea. El pico casi nunca cae justo en la frecuencia de la linea, por eso
          # se busca cerca. Las lineas vecinas estan a 10 MHz: quedan afuera.
          # Si la captura no llega hasta esa frecuencia, devuelve None.
          if linea < min(frecuencias) or linea > max(frecuencias):
              return None
          pico = None
          for j in range(len(frecuencias)):
              if abs(frecuencias[j] - linea) <= CERCA:
                  if pico is None or niveles[j] > pico:
                      pico = niveles[j]
          return pico


      def generar():
          # La captura tiene que ser del peine sin calibrar: con los contadores en 0
          if self.get_cargadas() > 0:
              self.set_estado_archivo('NO se genero: ya hay valores cargados. Cerrar el programa, '
                                      'abrirlo de nuevo y capturar el peine sin calibrar')
              return

          # 1) Elegir la captura. Se pueden elegir varias a la vez
          elegido = Qt.QFileDialog.getOpenFileNames(self, 'Elegir la captura del peine SIN calibrar', '',
                                                    'Capturas del analizador (*.csv)')
          nombres = elegido[0]
          if len(nombres) == 0:
              return                                   # se cerro la ventana sin elegir nada

          # 2) Leer cada captura
          capturas = []
          for nombre in nombres:
              try:
                  frecuencias, niveles = leer_captura(nombre)
              except Exception:
                  frecuencias = []
              if len(frecuencias) == 0:
                  self.set_estado_archivo('NO se genero: no se pudo leer ' + os.path.basename(nombre))
                  return
              capturas.append([frecuencias, niveles])

          # 3) Buscar el pico de cada linea
          ganancia = self.get_ganancia()               # ganancia de TX elegida en la ventana
          esperado = self.get_nivel_sin_calibrar()     # nivel aproximado de una linea sin calibrar
          valores = []                                 # un valor por linea; None si no hay dato
          for k in range(len(contadores)):
              linea = PRIMERA_LINEA + SEPARACION * k
              leidos = []
              for captura in capturas:
                  pico = pico_de_la_linea(captura[0], captura[1], linea)
                  if pico is not None:
                      leidos.append(pico)
              if len(leidos) == 0:
                  valores.append(None)                 # ninguna captura llega hasta esta linea
                  continue
              # Con varias capturas se usa el valor mas bajo: MAX HOLD a veces retiene
              # un pico momentaneo, y es raro que caiga dos veces en la misma linea
              valor = min(leidos)
              # Control: si el valor esta lejos de lo esperado, la captura no sirve
              if valor > esperado + 6 or valor < esperado - 8:
                  self.set_estado_archivo('NO se genero: en %d MHz se leyo %.1f dBm y con ganancia %d dB '
                                          'se esperaba cerca de %d dBm' % (linea, valor, ganancia, esperado))
                  return
              valores.append(valor)

          # 4) Cargar los contadores. El flujo espera valores leidos con la ganancia
          #    de lectura (45 dB): se resta lo que haya de mas en la ganancia usada
          diferencia = ganancia - self.get_ganancia_de_lectura()
          cuantas = 0
          for k in range(len(contadores)):
              if valores[k] is not None:
                  contadores[k].setValue(round(valores[k] - diferencia, 1))
                  cuantas = cuantas + 1
          if cuantas == 0:
              self.set_estado_archivo('NO se genero: la captura no llega a ninguna linea del peine')
              return

          # 5) Guardar el archivo de calibracion
          if guardar():
              self.set_estado_archivo('generada a las %s con %d captura(s): %d lineas, leidas con ganancia %d dB'
                                      % (time.strftime('%H:%M:%S'), len(capturas), cuantas, ganancia))


      # GNU Radio llama a set_boton_guardar(1) cuando se aprieta el boton y a
      # set_boton_guardar(0) cuando se suelta. Aca se define que hace esa llamada.
      def al_tocar_guardar(valor):
          if valor == 1:
              guardar()


      def al_tocar_importar(valor):
          if valor == 1:
              importar()


      # Este se hace al soltar el boton: si se hiciera al apretarlo, el boton quedaria
      # hundido mientras esta abierta la ventana para elegir el archivo.
      def al_tocar_generar(valor):
          if valor == 0:
              generar()


      self.set_boton_guardar = al_tocar_guardar
      self.set_boton_importar = al_tocar_importar
      self.set_boton_generar = al_tocar_generar
  states: {}

connections:
- [tono_superior, '0', suma, '0']
- [tono_inferior, '0', suma, '1']
- [suma, '0', osmosdr_sink_0, '0']
- [datos_comp, '0', ritmo_grafico, '0']
- [ritmo_grafico, '0', grafico, '0']
- [datos_actual, '0', grafico, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
