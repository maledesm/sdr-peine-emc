options:
  parameters:
    description: 'DEMO SIN PLACA: el tono va a un Null Sink y la ventana carga datos de ejemplo. bladeRF 2.0 micro xA9: 96 lineas cada 10 MHz de 50 a 1000 MHz, un tono por portadora, con la portadora 6,25 o 10 MHz por encima de la linea y 40 MSPS. Reiniciar deja todas las lineas con la misma amplitud y el objetivo plano. Calibracion conducida con la tinySA hacia el objetivo, calibracion irradiada relativa con las trazas .DAT del receptor del laboratorio hacia CISPR 11 grupo 1 clase A, y patron por cable para repetir la emision otro dia. SOLO hacia la tinySA o la antena: nunca con el cable en RX1'
    generate_options: qt_gui
    id: exp28_a9_peine_demo
    output_language: python
    title: 'EXP-28 DEMO SIN PLACA: peine cada 10 MHz (no transmite nada)'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Tasa de muestreo atada a la separacion: 20
      MSPS con la portadora a 6,25 MHz y 30 MSPS
      con 10 MHz. La imagen del muestreo cae 20 o
      30 MHz arriba de la linea, sobre la grilla.
      Cambiar la separacion solo en PAUSA
    value: 20e6 if separacion == 6.25 else 30e6
  states: {}
- name: ancho_banda
  id: variable
  parameters:
    comment: Filtro analogico de la placa
    value: 0.9 * samp_rate
  states: {}
- name: f_primera
  id: variable
  parameters:
    comment: Primera linea del peine
    value: 50e6
  states: {}
- name: paso_lineas
  id: variable
  parameters:
    comment: Separacion entre lineas
    value: 10e6
  states: {}
- name: n_lineas
  id: variable
  parameters:
    comment: 'Cantidad de lineas: 96, de 50 a 1000 MHz'
    value: '96'
  states: {}
- name: muestras_por_bloque
  id: variable
  parameters:
    comment: |-
      Muestras en cada envio por USB. Con bloques
      grandes anduvieron los 40 MSPS en el EXP-22
    value: '16384'
  states: {}
- name: bloques_usb
  id: variable
  parameters:
    comment: |-
      Bloques USB de 16384 muestras: 64 guardan 52
      ms a 20 MSPS y 35 ms a 30 MSPS. La amplitud
      llega a la salida con ese retardo, por eso
      el corte minimo es de 0,2 s
    value: '64'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: |-
      import os
      import math
  states: {}
- name: ganancia_de_lectura
  id: variable
  parameters:
    comment: |-
      Ganancia de TX a la que esta referida la
      respuesta de la placa
    value: '45'
  states: {}
- name: amp_base
  id: variable
  parameters:
    comment: Amplitud del tono sin compensar
    value: '0.25'
  states: {}
- name: amp_max
  id: variable
  parameters:
    comment: Amplitud maxima del tono. No debe llegar a 1
    value: '0.95'
  states: {}
- name: prefijo
  id: variable
  parameters:
    comment: |-
      Comienzo del nombre de los archivos de esta
      version, para que no se mezclen con los de
      las otras
    value: '''demo_'''
  states: {}
- name: texto_salida
  id: variable
  parameters:
    comment: Se muestra en la ventana
    value: '''SIN PLACA (demo)'''
  states: {}
- name: archivo_cal
  id: variable
  parameters:
    comment: |-
      Archivo de la calibracion conducida, en la
      carpeta del flujo
    value: prefijo + 'calibracion_conducida.txt'
  states: {}
- name: archivo_obj
  id: variable
  parameters:
    comment: |-
      Archivo del objetivo actual. Se carga solo
      al abrir el programa
    value: prefijo + 'objetivo.txt'
  states: {}
- name: archivo_irr
  id: variable
  parameters:
    comment: |-
      Lo medido en la ultima calibracion
      irradiada. Se carga solo al abrir
    value: prefijo + 'ultima_irradiada.txt'
  states: {}
- name: objetivo
  id: variable
  parameters:
    comment: |-
      Nivel por cable de cada linea, en dBm. Lo
      carga el snippet desde el archivo. No
      depende de nivel_inicial a proposito:
      cambiar ese campo no tiene que pisar la
      calibracion
    value: '[-33.0] * n_lineas'
  states: {}
- name: estado_cal
  id: variable
  parameters:
    comment: |-
      Texto sobre la calibracion conducida. Lo
      cambian los botones
    value: ''''''
  states: {}
- name: estado_obj
  id: variable
  parameters:
    comment: |-
      Texto sobre el objetivo. Lo cambian los
      botones
    value: ''''''
  states: {}
- name: estado_irr
  id: variable
  parameters:
    comment: Texto sobre la ultima calibracion irradiada
    value: ''''''
  states: {}
- name: medido_irradiado
  id: variable
  parameters:
    comment: |-
      Mayor nivel de las trazas en cada linea en la
      ultima calibracion irradiada, en dBuV/m
    value: '[0.0] * n_lineas'
  states: {}
- name: separacion_cal
  id: variable
  parameters:
    comment: |-
      Separacion de la portadora con que se hizo la
      calibracion conducida cargada. 0 es que no
      se sabe. La ponen los botones
    value: '0.0'
  states: {}
- name: pausa
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 1,0,1,4
    label: 'PAUSA: salida en silencio. Destildar para transmitir'
    type: int
    'true': '1'
    'false': '0'
    value: '0'
  states: {}
- name: congelar
  id: variable_qtgui_check_box
  parameters:
    comment: |-
      Detiene el barrido en la linea que esta
      saliendo y la deja emitiendo. Al destildar,
      el barrido sigue desde ahi
    gui_hint: 1,4,1,4
    label: CONGELAR en la linea actual (sigue emitiendo)
    type: int
    'true': '1'
    'false': '0'
    value: '0'
  states: {}
- name: silencio
  id: variable_qtgui_check_box
  parameters:
    comment: |-
      Tildada: despues de cada linea encendida
      viene el mismo tiempo apagada
    gui_hint: 1,8,1,4
    label: 'Silencio largo: cada linea queda apagada otro tanto'
    type: int
    'true': '1'
    'false': '0'
    value: '0'
  states: {}
- name: ganancia
  id: variable_qtgui_range
  parameters:
    comment: |-
      Tope de 55 dB: la tinySA va sin atenuador
      y aguanta +6 dBm
    gui_hint: 2,0,1,3
    label: Ganancia de TX (dB)
    min_len: '50'
    start: '0'
    step: '1'
    stop: '55'
    value: '31'
    widget: counter
  states: {}
- name: separacion
  id: variable_qtgui_chooser
  parameters:
    comment: MHz entre la linea y la portadora
    gui_hint: 2,3,1,3
    label: Portadora sobre la linea
    labels: '[''6,25 MHz'', ''10 MHz'']'
    options: '[6.25, 10]'
    num_opts: '0'
    type: real
    value: '6.25'
  states: {}
- name: fijo
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Barrido completo, o una sola linea emitida
      en forma continua (para orientar las antenas
      o mirar sus armonicos)
    gui_hint: 2,6,1,3
    label: Modo
    labels: '[''Barrido completo''] + [''Fija en %d MHz'' % (50 + 10 * k) for k in range(96)]'
    options: '[-1] + list(range(96))'
    num_opts: '0'
    type: int
    value: '-1'
  states: {}
- name: permanencia
  id: variable_qtgui_range
  parameters:
    comment: |-
      Tiene que superar dos barridos del receptor.
      Cambiarla en PAUSA: el barrido se reacomoda
    gui_hint: 3,0,1,3
    label: Segundos encendida por linea
    min_len: '50'
    start: '1'
    step: '0.5'
    stop: '30'
    value: '7'
    widget: counter
  states: {}
- name: corte
  id: variable_qtgui_range
  parameters:
    comment: |-
      Tono apagado alrededor de cada salto, para
      que el MAX HOLD no tome el salto. Minimo 0,2 s:
      la amplitud tarda 0,05 s en llegar
    gui_hint: 3,3,1,3
    label: Corte en cada salto (s)
    min_len: '50'
    start: '0.2'
    step: '0.1'
    stop: '3'
    value: '0.5'
    widget: counter
  states: {}
- name: lista_de_pasos
  id: variable
  parameters:
    comment: |-
      Los pasos del barrido. pop() saca el ultimo:
      0, 1, 2, ... (alcanza para mas de 27 horas)
    value: list(range(1000000 - 1, -1, -1))
  states: {}
- name: paso
  id: variable_function_probe
  parameters:
    block_id: lista_de_pasos
    comment: |-
      Cada decima de segundo saca el ultimo numero
      de la lista: cuenta decimas desde el arranque
    function_name: pop
    poll_rate: '10'
    value: '-1'
  states: {}
- name: decima
  id: variable
  parameters:
    comment: Decimas de segundo desde el arranque
    value: max(paso, 0)
  states: {}
- name: encendido
  id: variable
  parameters:
    comment: Decimas con el tono encendido en cada linea
    value: int(round(10 * permanencia))
  states: {}
- name: apagado
  id: variable
  parameters:
    comment: |-
      Decimas apagado entre dos lineas: el corte,
      mas el silencio largo si esta tildado
    value: int(round(10 * (corte + (permanencia if silencio == 1 else 0))))
  states: {}
- name: antes
  id: variable
  parameters:
    comment: |-
      Decimas apagado al principio de cada linea.
      El resto va al final: asi el salto queda en
      el medio del apagado
    value: apagado // 2
  states: {}
- name: por_linea
  id: variable
  parameters:
    comment: 'Decimas por linea: apagado y encendido'
    value: encendido + apagado
  states: {}
- name: ciclo
  id: variable
  parameters:
    comment: Numero de linea desde el arranque
    value: decima // por_linea
  states: {}
- name: dentro
  id: variable
  parameters:
    comment: Decimas dentro de la linea actual
    value: decima % por_linea
  states: {}
- name: en_corte
  id: variable
  parameters:
    comment: 1 mientras el tono esta apagado
    value: 0 if antes <= dentro < antes + encendido else 1
  states: {}
- name: posicion
  id: variable
  parameters:
    comment: Lugar dentro de la pasada, desde 0
    value: ciclo % n_lineas
  states: {}
- name: pasada
  id: variable
  parameters:
    comment: Cuantas veces se recorrio el peine
    value: ciclo // n_lineas + 1
  states: {}
- name: indice
  id: variable
  parameters:
    comment: Linea actual, de 0 a 95
    value: fijo if fijo >= 0 else posicion
  states: {}
- name: linea
  id: variable
  parameters:
    comment: Frecuencia de la linea actual
    value: f_primera + paso_lineas * indice
  states: {}
- name: f_tono
  id: variable
  parameters:
    comment: |-
      El tono va por debajo de la portadora: asi
      la linea de 50 MHz no obliga a sintonizar
      por debajo de 47 MHz
    value: '-separacion * 1e6'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: Frecuencia de la portadora
    value: linea - f_tono
  states: {}
- name: emite
  id: variable
  parameters:
    comment: 1 cuando el tono esta encendido
    value: 1 if (pausa == 0 and paso >= 0 and (fijo >= 0 or congelar == 1 or en_corte == 0)) else 0
  states: {}
- name: medidos
  id: variable
  parameters:
    comment: |-
      Lo que entrega la placa en cada linea con la
      amplitud base y la ganancia de lectura, en
      dBm. 0 es sin dato. Lo cargan los botones
    value: '[0.0] * n_lineas'
  states: {}
- name: pedido
  id: variable
  parameters:
    comment: |-
      Cuanto hay que subir (o bajar) la amplitud de
      cada linea, en dB, para llegar a su objetivo.
      Sin dato, sale con la amplitud base
    value: '[((objetivo[k] - (medidos[k] + ganancia - ganancia_de_lectura)) if medidos[k] != 0 else 0.0) for k in range(n_lineas)]'
  states: {}
- name: amp_tabla
  id: variable
  parameters:
    comment: |-
      Amplitud del tono para cada linea, con tope
      en amp_max
    value: '[min(amp_base * 10 ** (db / 20.0), amp_max) for db in pedido]'
  states: {}
- name: sin_margen
  id: variable
  parameters:
    comment: Lineas que piden mas amplitud de la que hay
    value: sum(1 for db in pedido if amp_base * 10 ** (db / 20.0) > amp_max)
  states: {}
- name: cargadas
  id: variable
  parameters:
    comment: Lineas que ya tienen un valor cargado
    value: sum(1 for leido in medidos if leido != 0)
  states: {}
- name: ganancia_minima
  id: variable
  parameters:
    comment: |-
      La menor ganancia con la que ninguna linea
      pide mas de amp_max. Con la base de 0,25 y el
      tope de 0,95 se puede subir hasta 11,6 dB
    value: int(math.ceil(ganancia_de_lectura + max([objetivo[k] - medidos[k] for k in range(n_lineas) if medidos[k] != 0]) - 20 * math.log10(amp_max / amp_base))) if cargadas > 0 else 0
  states: {}
- name: nivel_sin_calibrar
  id: variable
  parameters:
    comment: |-
      Nivel aproximado de una linea sin calibrar,
      en dBm, segun la ganancia elegida
    value: ganancia - 68
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: |-
      Ganancia que recibe la placa: en pausa baja
      al minimo
    value: ganancia if pausa == 0 else 0
  states: {}
- name: amp_tx
  id: variable
  parameters:
    comment: Amplitud del tono de esta linea
    value: amp_tabla[indice] if emite == 1 else 0
  states: {}
- name: nivel_estimado
  id: variable
  parameters:
    comment: |-
      Lo que deberia salir por cable en cada linea
      con la ganancia y la amplitud actuales
    value: '[((medidos[k] + ganancia - ganancia_de_lectura) + 20 * math.log10(amp_tabla[k] / amp_base)) if medidos[k] != 0 else -100 for k in range(n_lineas)]'
  states: {}
- name: etapa
  id: variable
  parameters:
    comment: Texto de la etapa actual
    value: '''PAUSA (sin emitir)'' if pausa == 1 else (''INICIACION'' if paso < 0 else (''LINEA FIJA, emision continua'' if fijo >= 0 else (''LINEA CONGELADA, emision continua'' if congelar == 1 else (''CORTE (salto de linea)'' if en_corte == 1 else ''EMITIENDO''))))'
  states: {}
- name: limite_lineas
  id: variable
  parameters:
    comment: |-
      CISPR 11 grupo 1 clase A a 3 m: 50 dBuV/m
      hasta 230 MHz y 57 arriba
    value: '[(50.0 if f_primera / 1e6 + 10 * k <= 230 else 57.0) for k in range(n_lineas)]'
  states: {}
- name: et_etapa
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:15pt; color:" + (''#c0392b'' if ''PAUSA'' in str(x) else (''#d68910'' if ''CORTE'' in str(x) else (''#2e86c1'' if ''LINEA'' in str(x) else (''#1e8449'' if ''EMITIENDO'' in str(x) else ''gray'')))) + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,0,1,4
    label: '<span style=''font-size:15pt''>Etapa: </span>'
    type: string
    value: etapa
  states: {}
- name: et_linea
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:15pt; color:" + (''black'') + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,4,1,4
    label: '<span style=''font-size:15pt''>Linea: </span>'
    type: string
    value: ('%.0f MHz (fija)' % (linea / 1e6)) if fijo >= 0 else '%.0f MHz (%d de %d, pasada %d)' % (linea / 1e6, posicion + 1, n_lineas, pasada)
  states: {}
- name: et_portadora
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:15pt; color:" + (''black'') + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,8,1,4
    label: '<span style=''font-size:15pt''>Portadora: </span>'
    type: string
    value: '''%.2f MHz'' % (freq / 1e6)'
  states: {}
- name: et_tiempos
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt; color:" + (''black'') + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 3,6,1,6
    label: '<span style=''font-size:11pt''>Pasada completa: </span>'
    type: string
    value: '''%d min %02d s (%.1f s encendida y %.1f s apagada por linea)'' % (n_lineas * por_linea // 600, (n_lineas * por_linea // 10) % 60, encendido / 10.0, apagado / 10.0)'
  states: {}
- name: et_nivel
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt; color:" + (''black'') + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 4,0,1,6
    label: '<span style=''font-size:11pt''>Esta linea: </span>'
    type: string
    value: '''amplitud %.3f, sale unos %.1f dBm (objetivo %.1f dBm)'' % (amp_tabla[indice], nivel_estimado[indice], objetivo[indice])'
  states: {}
- name: et_espurias
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt; color:" + (''black'') + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 4,6,1,6
    label: '<span style=''font-size:11pt''>Sus espurias (MHz): </span>'
    type: string
    value: '''fuga %.2f, imagen %.2f, 3C+S %.2f, 5C-S %.2f'' % (freq / 1e6, freq / 1e6 + separacion, 3 * freq / 1e6 + separacion, 5 * freq / 1e6 - separacion)'
  states: {}
- name: et_cargadas
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt; color:" + (''#c0392b'' if ''NO coincide'' in str(x) else ''black'') + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 5,0,1,3
    label: '<span style=''font-size:11pt''>Conducida: </span>'
    type: string
    value: '(''%d/%d'' % (cargadas, n_lineas)) + (('', es de %g MHz: NO coincide'' % separacion_cal) if (cargadas > 0 and separacion_cal != 0 and separacion_cal != separacion) else (('', de %g MHz'' % separacion_cal) if separacion_cal != 0 else ''''))'
  states: {}
- name: et_margen
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt; color:" + (''#c0392b'' if x > 0 else ''#1e8449'') + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 5,3,1,3
    label: '<span style=''font-size:11pt''>Lineas sin margen: </span>'
    type: int
    value: sin_margen
  states: {}
- name: et_gmin
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt; color:" + (''black'') + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 5,6,1,3
    label: '<span style=''font-size:11pt''>Ganancia minima: </span>'
    type: string
    value: ('%d dB' % ganancia_minima) if cargadas > 0 else 'sin calibracion conducida'
  states: {}
- name: et_cal
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt; color:" + (''#c0392b'' if (str(x).startswith(''NO'') or ''FUERA'' in str(x) or ''OJO'' in str(x)) else (''#1e8449'' if ''dentro'' in str(x) else ''black'')) + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 8,0,1,12
    label: '<span style=''font-size:11pt''>Calibracion conducida: </span>'
    type: string
    value: estado_cal
  states: {}
- name: et_irr
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt; color:" + (''#c0392b'' if (str(x).startswith(''NO'') or ''FUERA'' in str(x) or ''OJO'' in str(x)) else ''black'') + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 9,0,1,12
    label: '<span style=''font-size:11pt''>Ultima irradiada: </span>'
    type: string
    value: estado_irr
  states: {}
- name: et_obj
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt; color:" + (''#c0392b'' if (str(x).startswith(''NO'') or ''FUERA'' in str(x) or ''OJO'' in str(x)) else ''black'') + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 10,0,1,12
    label: '<span style=''font-size:11pt''>Objetivo y patron: </span>'
    type: string
    value: estado_obj
  states: {}
- name: et_salida
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt; color:" + (''#d68910'' if ''SIN PLACA'' in str(x) else (''#2e86c1'' if ''casa'' in str(x) else ''#1e8449'')) + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 5,9,1,3
    label: '<span style=''font-size:11pt''>Salida: </span>'
    type: string
    value: texto_salida + ', %.0f MSPS' % (samp_rate / 1e6)
  states: {}
- name: boton_conducida
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 6,0,1,4
    label: 1. Calibracion conducida (captura .csv de la tinySA)
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: boton_irradiada
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 6,4,1,4
    label: 2. Calibracion irradiada (UNA traza .DAT del receptor)
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: boton_guardar_patron
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 6,8,1,4
    label: 3. Guardar patron (captura .csv de la tinySA)
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: tono
  id: analog_sig_source_x
  parameters:
    comment: |-
      Un solo tono, 'separacion' MHz por debajo de
      la portadora
    amp: amp_tx
    freq: f_tono
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: curva_actual
  id: variable
  parameters:
    comment: Marca la linea que sale ahora
    value: '[(objetivo[k] if (k == indice and emite == 1) else -100) for k in range(n_lineas)]'
  states: {}
- name: nivel_respuesta
  id: variable
  parameters:
    comment: |-
      Lo que saldria en cada linea con la amplitud
      base, sin compensar, con la ganancia actual
    value: '[(medidos[k] + ganancia - ganancia_de_lectura) if medidos[k] != 0 else -100 for k in range(n_lineas)]'
  states: {}
- name: curva_irradiada
  id: variable
  parameters:
    comment: |-
      Lo medido en la ultima irradiada, para el
      grafico (sin dato queda abajo)
    value: '[(v if v != 0 else -100) for v in medido_irradiado]'
  states: {}
- name: datos_obj
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: objetivo
    vlen: '96'
  states: {}
- name: datos_est
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: nivel_estimado
    vlen: '96'
  states: {}
- name: datos_actual
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: curva_actual
    vlen: '96'
  states: {}
- name: datos_resp
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: nivel_respuesta
    vlen: '96'
  states: {}
- name: ritmo_grafico
  id: blocks_throttle2
  parameters:
    comment: Solo marca el ritmo del grafico
    limit: time
    maximum: '0.01'
    samples_per_second: '2000'
    type: float
    vlen: '96'
  states: {}
- name: grafico
  id: qtgui_vector_sink_f
  parameters:
    name: '"Nivel por cable de cada linea (dBm)"'
    vlen: '96'
    x_start: f_primera / 1e6
    x_step: paso_lineas / 1e6
    x_axis_label: '"Frecuencia de la linea"'
    y_axis_label: '"Nivel"'
    x_units: '"MHz"'
    y_units: '"dBm"'
    grid: 'True'
    ymin: '-60'
    ymax: '-10'
    nconnections: '4'
    gui_hint: 11,0,2,12
    label1: '"Objetivo"'
    width1: '3'
    label2: '"Lo que sale (estimado)"'
    width2: '2'
    color2: '"green"'
    label3: '"Linea que sale ahora"'
    label4: '"Respuesta de la placa, sin compensar"'
    width3: '4'
    width4: '2'
    color3: '"red"'
  states: {}
- name: datos_mascara
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: limite_lineas
    vlen: '96'
  states: {}
- name: datos_irr
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: curva_irradiada
    vlen: '96'
  states: {}
- name: ritmo_grafico_2
  id: blocks_throttle2
  parameters:
    comment: Solo marca el ritmo del grafico
    limit: time
    maximum: '0.01'
    samples_per_second: '2000'
    type: float
    vlen: '96'
  states: {}
- name: grafico_irradiado
  id: qtgui_vector_sink_f
  parameters:
    name: '"Campo en la camara, ultima calibracion irradiada (dBuV/m)"'
    vlen: '96'
    x_start: f_primera / 1e6
    x_step: paso_lineas / 1e6
    x_axis_label: '"Frecuencia de la linea"'
    y_axis_label: '"Campo"'
    x_units: '"MHz"'
    y_units: '"dBuV/m"'
    grid: 'True'
    ymin: '20'
    ymax: '80'
    nconnections: '2'
    gui_hint: 13,0,2,12
    label1: '"Mascara CISPR 11 G1 clase A"'
    width1: '3'
    color1: '"red"'
    label2: '"Medido en la ultima irradiada"'
    width2: '3'
    color2: '"blue"'
  states: {}
- name: archivos_de_calibracion
  id: snippet
  parameters:
    comment: |-
      Reiniciar, calibracion conducida, irradiada
      y patron: lee y escribe los archivos.
      Tambien pone la letra y los colores
    section: main_after_init
    code: |
      # ============================================================================
      # ARCHIVOS DE CALIBRACION, OBJETIVO Y PATRON
      # Es el unico codigo Python del flujo. Hace falta porque los bloques no saben
      # leer ni escribir archivos. Es igual en las tres versiones (CETEM, casa y
      # demo): lo que cambia lo dicen los bloques Variable prefijo,
      # irradiada_tinysa y factor_antena.
      #   "Reiniciar calibracion": todas las lineas vuelven a la misma amplitud y el
      #      objetivo queda plano en el nivel elegido. Antes guarda una copia de
      #      todo en la carpeta respaldos.
      #   1. "Calibracion conducida": pide la captura (.csv) de la tinySA con el
      #      peine tal como esta saliendo, busca el pico de cada linea y calcula
      #      cuanto entrega la placa en cada una, para que salga el objetivo. Se
      #      puede repetir para afinar, y cada vez dice a cuantos dB del objetivo
      #      estaba lo que se leyo.
      #   2. "Calibracion irradiada": pide UNA traza del receptor (.DAT, en dBuV/m)
      #      y le suma al objetivo lo que le falta o le sobra a cada linea para
      #      llegar al limite de CISPR 11 grupo 1 clase A. Es relativa a lo que esta
      #      cargado: con otra traza se hace un ajuste fino. La misma traza no se
      #      puede usar dos veces.
      #      En la version de casa la traza es una captura (.csv) de la tinySA con
      #      su antena, en dBm, y se pasa a dBuV/m con el factor de antena.
      #   3. "Guardar patron": pide una captura (.csv) del peine ya calibrado y
      #      guarda el nivel por cable de cada linea.
      #   "Cargar patron": pone un patron guardado como objetivo, para que la
      #      calibracion conducida vuelva a sacar lo mismo otro dia.
      # La tasa de muestreo va atada a la separacion (20 o 30 MSPS): la calibracion
      # y el patron anotan las dos y solo valen para ellas.
      # ============================================================================
      import hashlib
      import math
      import os
      import shutil
      import time

      PRIMERA_LINEA = 50        # MHz
      SEPARACION = 10           # MHz entre una linea y la siguiente
      CANTIDAD = 96             # lineas, de 50 a 1000 MHz
      CERCA_TINYSA = 3          # MHz: hasta que distancia de una linea se busca su pico en la tinySA
      CERCA_RECEPTOR = 1        # MHz: lo mismo en las trazas del receptor
      MAXIMA_CORRECCION = 15    # dB: una correccion irradiada mas grande que esto no se aplica (con las
                                # trazas del 13-10, desde -33 dBm planos hacen falta hasta 13,8 dB)
      MAXIMO_SIN_CORREGIR = 10  # lineas: con mas lineas lejos del limite, la traza no es la que corresponde
      TOLERANCIA = 1            # dB: la conducida tiene que quedar a +/- esto del objetivo
      DE_DBM_A_DBUV = 107       # en 50 ohm, 0 dBm son 107 dBuV

      # Los archivos se leen y se escriben en la carpeta del programa, aunque se lo
      # abra desde otro lado
      os.chdir(os.path.dirname(os.path.abspath(__file__)))


      def frecuencia_de_linea(k):
          return PRIMERA_LINEA + SEPARACION * k


      def limite_de_la_mascara(frecuencia):
          # CISPR 11:2024 grupo 1 clase A, a 3 m en camara semianecoica, en dBuV/m.
          # En 230 MHz justo vale el limite mas bajo.
          if frecuencia <= 230:
              return 50.0
          return 57.0


      def ahora():
          return time.strftime('%d-%m-%Y %H:%M')


      # ---------------------------------------------------------------- lectura de archivos

      def leer_captura_tinysa(nombre):
          # Lee una captura de la tinySA (.csv): un renglon por punto, con la
          # frecuencia en MHz y el nivel en dBm separados por coma. Devuelve dos
          # listas: MHz y dBm.
          frecuencias = []
          niveles = []
          archivo = open(nombre, errors='ignore')
          for renglon in archivo:
              partes = renglon.split(',')
              try:
                  frecuencia = float(partes[0])
                  nivel = float(partes[1])
              except Exception:
                  continue                             # renglon de titulo o vacio: se saltea
              if frecuencia > 100000:
                  frecuencia = frecuencia / 1e6        # estaba en Hz: se pasa a MHz
              frecuencias.append(frecuencia)
              niveles.append(nivel)
          archivo.close()
          return frecuencias, niveles


      def es_dbuv_por_metro(unidad):
          # La u griega de dBuV/m puede venir de varias formas: chr(181) es el signo
          # de micro, chr(956) la letra griega mu y chr(194) una A que aparece
          # delante si el archivo se guardo en UTF-8. Se pasan todas a una u comun.
          texto = unidad.replace(chr(194), '').replace(chr(181), 'u').replace(chr(956), 'u')
          return texto.strip().lower() == 'dbuv/m'


      def leer_traza_receptor(nombre):
          # Lee una traza del receptor R&S ESR-7 (.DAT): un encabezado con pares
          # nombre;valor y un renglon por punto con la frecuencia en Hz y el nivel,
          # separados por punto y coma. Devuelve las frecuencias (MHz), los niveles
          # (dBuV/m) y un texto con el problema ('' si esta todo bien).
          frecuencias = []
          niveles = []
          unidad = ''
          trazas = 0
          archivo = open(nombre, encoding='latin-1')   # latin-1 lee cualquier byte, tambien la u griega
          for renglon in archivo:
              partes = renglon.strip().split(';')
              if partes[0] == 'y-Unit' and len(partes) > 1:
                  unidad = partes[1]
              if partes[0].startswith('TRACE'):
                  trazas = trazas + 1
              try:
                  frecuencia = float(partes[0])
                  nivel = float(partes[1])
              except Exception:
                  continue                             # renglon del encabezado: se saltea
              if frecuencia > 100000:
                  frecuencia = frecuencia / 1e6        # estaba en Hz: se pasa a MHz
              frecuencias.append(frecuencia)
              niveles.append(nivel)
          archivo.close()
          if trazas > 1:
              return [], [], 'el archivo trae %d trazas y tiene que traer una sola' % trazas
          if unidad == '':
              return [], [], 'el archivo no dice en que unidad esta (falta el renglon y-Unit)'
          if not es_dbuv_por_metro(unidad):
              return [], [], 'la traza esta en %s y tiene que estar en dBuV/m' % unidad
          if len(frecuencias) == 0:
              return [], [], 'el archivo no tiene puntos (o los numeros vienen con coma decimal)'
          return frecuencias, niveles, ''


      def leer_varias_capturas(nombres):
          # Lee varias capturas de la tinySA. Devuelve la lista de capturas, o None si
          # alguna falla
          capturas = []
          for nombre in nombres:
              try:
                  frecuencias, niveles = leer_captura_tinysa(nombre)
              except Exception:
                  frecuencias = []
              if len(frecuencias) == 0:
                  return None
              capturas.append([frecuencias, niveles])
          return capturas


      def pico_de_la_linea(frecuencias, niveles, linea, cerca):
          # Devuelve el nivel mas alto que hay en la captura a menos de 'cerca' MHz de
          # la linea. Si la captura no llega hasta esa frecuencia, devuelve None.
          if linea < min(frecuencias) or linea > max(frecuencias):
              return None
          pico = None
          for j in range(len(frecuencias)):
              if abs(frecuencias[j] - linea) <= cerca:
                  if pico is None or niveles[j] > pico:
                      pico = niveles[j]
          return pico


      def menor_de_las_capturas(capturas, k):
          # El nivel de la linea k en cada captura, y se queda con el menor: MAX HOLD
          # a veces retiene un pico momentaneo, y es raro que caiga dos veces en la
          # misma linea. Devuelve None si ninguna captura llega hasta esa linea.
          leidos = []
          for captura in capturas:
              pico = pico_de_la_linea(captura[0], captura[1], frecuencia_de_linea(k), CERCA_TINYSA)
              if pico is not None:
                  leidos.append(pico)
          if len(leidos) == 0:
              return None
          return min(leidos)


      def leer_archivo_de_valores(nombre):
          # Lee un archivo con un renglon por linea: frecuencia y valor. Los renglones
          # que empiezan con # son comentarios. Devuelve los 96 valores.
          archivo = open(nombre, encoding='utf-8', errors='replace')
          valores = []
          for renglon in archivo:
              if renglon.startswith('#') or renglon.strip() == '':
                  continue
              partes = renglon.split()
              valores.append(float(partes[1]))
          archivo.close()
          if len(valores) != CANTIDAD:
              raise ValueError('el archivo no tiene 96 valores')
          return valores


      def encabezado(nombre):
          # El primer renglon del archivo, sin el # del principio
          archivo = open(nombre, encoding='utf-8', errors='replace')
          primero = archivo.readline()
          archivo.close()
          return primero.lstrip('#').strip()


      def numero_del_encabezado(nombre, palabra):
          # Busca la palabra en el primer renglon del archivo y devuelve el numero que
          # le sigue (por ejemplo 'portadora 6.25' o 'ganancia 31'). Si no esta,
          # devuelve 0.
          partes = encabezado(nombre).replace(',', ' ').split()
          for i in range(len(partes) - 1):
              if partes[i] == palabra:
                  try:
                      return float(partes[i + 1])
                  except Exception:
                      return 0.0
          return 0.0


      def tasa_de_la_separacion(separacion):
          # La tasa de muestreo va atada a la separacion (bloque samp_rate): 20 MSPS
          # con la portadora a 6,25 MHz y 30 MSPS con 10 MHz
          if separacion == 6.25:
              return 20.0
          return 30.0


      def es_de_otra_tasa(nombre):
          # Una calibracion o un patron valen para la tasa con que se hicieron. Los
          # que no dicen la tasa son de la version anterior del flujo, a 40 MSPS
          portadora = numero_del_encabezado(nombre, 'portadora')
          tasa = numero_del_encabezado(nombre, 'tasa')
          return portadora == 0 or tasa != tasa_de_la_separacion(portadora)


      def escribir_archivo_de_valores(nombre, texto, valores):
          archivo = open(nombre, 'w', encoding='utf-8')
          archivo.write('# ' + texto + '\n')
          for k in range(CANTIDAD):
              archivo.write('%d %.1f\n' % (frecuencia_de_linea(k), valores[k]))
          archivo.close()


      def guardar_respaldo(nombre, cuando):
          # Copia el archivo a la carpeta respaldos antes de pisarlo o de borrarlo
          if os.path.exists(nombre):
              if not os.path.isdir('respaldos'):
                  os.mkdir('respaldos')
              shutil.copyfile(nombre, os.path.join('respaldos', cuando + '_' + nombre))


      # ---------------------------------------------------------------- trazas ya usadas

      def huella_del_archivo(nombre):
          # Un codigo de 32 letras que sale de todo el contenido del archivo: dos
          # archivos iguales dan el mismo codigo aunque tengan otro nombre, y dos
          # trazas distintas nunca dan el mismo
          archivo = open(nombre, 'rb')
          contenido = archivo.read()
          archivo.close()
          return hashlib.md5(contenido).hexdigest()


      def traza_ya_usada(huella):
          # Devuelve el renglon de trazas_usadas.txt con esa huella, o '' si la traza
          # no se uso nunca
          usadas = self.get_prefijo() + 'trazas_usadas.txt'
          if not os.path.exists(usadas):
              return ''
          archivo = open(usadas, encoding='utf-8', errors='replace')
          encontrada = ''
          for renglon in archivo:
              if renglon.startswith(huella):
                  encontrada = renglon[len(huella):].strip()
          archivo.close()
          return encontrada


      def anotar_traza_usada(huella, nombre):
          archivo = open(self.get_prefijo() + 'trazas_usadas.txt', 'a', encoding='utf-8')
          archivo.write(huella + ' ' + ahora() + ' ' + os.path.basename(nombre) + '\n')
          archivo.close()


      # ---------------------------------------------------------------- reiniciar

      def guardar_calibracion():
          # Se anota con que separacion de la portadora y que tasa se hizo: la
          # respuesta de la placa cambia un poco de una a otra
          escribir_archivo_de_valores(self.get_archivo_cal(),
                                      'guardada el ' + ahora() +
                                      ', valores leidos con ganancia %d dB' % self.get_ganancia_de_lectura() +
                                      ', portadora %g MHz sobre la linea' % self.get_separacion_cal() +
                                      ', tasa %g MSPS' % (self.get_samp_rate() / 1e6),
                                      self.get_medidos())


      def poner_objetivo_plano(motivo):
          nivel = self.get_nivel_inicial()
          self.set_objetivo([nivel] * CANTIDAD)
          escribir_archivo_de_valores(self.get_archivo_obj(),
                                      'objetivo plano de %.1f dBm, %s el %s' % (nivel, motivo, ahora()),
                                      self.get_objetivo())


      def reiniciar():
          pregunta = ('Se borran la calibracion conducida y las correcciones irradiadas: todas las lineas '
                      'vuelven a la misma amplitud y el objetivo queda plano en %.1f dBm.\n\n'
                      'Antes se guarda una copia en la carpeta respaldos.\n\nReiniciar?' % self.get_nivel_inicial())
          respuesta = Qt.QMessageBox.question(self, 'Reiniciar calibracion', pregunta,
                                              Qt.QMessageBox.Yes | Qt.QMessageBox.No, Qt.QMessageBox.No)
          if respuesta != Qt.QMessageBox.Yes:
              return
          try:
              cuando = time.strftime('%Y-%m-%d_%H%M%S')
              for nombre in [self.get_archivo_cal(), self.get_archivo_obj(), self.get_archivo_irr()]:
                  guardar_respaldo(nombre, cuando)
              for nombre in [self.get_archivo_cal(), self.get_archivo_irr()]:
                  if os.path.exists(nombre):
                      os.remove(nombre)
              poner_objetivo_plano('reiniciado')
          except Exception:
              self.set_estado_cal('NO se pudo reiniciar: no se pudo copiar o escribir algun archivo')
              return
          self.set_medidos([0.0] * CANTIDAD)
          self.set_separacion_cal(0.0)
          self.set_medido_irradiado([0.0] * CANTIDAD)
          self.set_estado_cal('reiniciada a las %s: todas las lineas con la misma amplitud (copia en respaldos)'
                              % time.strftime('%H:%M:%S'))
          self.set_estado_irr('ninguna desde que se reinicio')
          self.set_estado_obj('plano en %.1f dBm desde las %s' % (self.get_nivel_inicial(), time.strftime('%H:%M:%S')))


      # ---------------------------------------------------------------- 1. calibracion conducida

      def generar_conducida():
          # La captura tiene que ser del peine tal como esta saliendo ahora: sin
          # calibrar (la primera vez) o con la calibracion que esta cargada. El
          # programa sabe con que amplitud y que ganancia salio cada linea, y con eso
          # saca cuanto entrega la placa. No cambiar la ganancia ni el objetivo entre
          # la captura y el boton.
          elegido = Qt.QFileDialog.getOpenFileNames(self, 'Elegir la captura de la tinySA con el peine tal como esta saliendo',
                                                    '', 'Capturas de la tinySA (*.csv)')
          nombres = elegido[0]
          if len(nombres) == 0:
              return                                   # se cerro la ventana sin elegir nada
          capturas = leer_varias_capturas(nombres)
          if capturas is None:
              self.set_estado_cal('NO se genero: no se pudo leer alguna de las capturas')
              return

          ganancia = self.get_ganancia()               # ganancia de TX elegida en la ventana
          amplitudes = self.get_amp_tabla()            # con que amplitud salio cada linea
          anteriores = self.get_medidos()              # lo que habia cargado (0 = sin dato)
          estimados = self.get_nivel_estimado()        # lo que se esperaba leer en cada linea
          objetivo = self.get_objetivo()
          valores = []                                 # un valor por linea, o None si no hay dato
          desvios = []                                 # leido menos objetivo, en las lineas ya calibradas
          for k in range(CANTIDAD):
              if anteriores[k] != 0:
                  esperado = estimados[k]
              else:
                  esperado = self.get_nivel_sin_calibrar()
              valor = menor_de_las_capturas(capturas, k)
              if valor is None:
                  valores.append(None)                 # ninguna captura llega hasta esta linea
                  continue
              # Control: si el valor esta lejos de lo esperado, la captura no sirve
              if valor > esperado + 6 or valor < esperado - 10:
                  self.set_estado_cal('NO se genero: en %d MHz se leyo %.1f dBm y se esperaba cerca de %.1f dBm'
                                      % (frecuencia_de_linea(k), valor, esperado))
                  return
              if anteriores[k] != 0:
                  desvios.append(valor - objetivo[k])
              # Lo que entrega la placa con la amplitud base y la ganancia de lectura
              # (45 dB): a lo leido se le descuenta cuanto se subio la amplitud de esa
              # linea y cuanto de mas tiene la ganancia usada
              subida = 20 * math.log10(amplitudes[k] / self.get_amp_base())
              de_mas = ganancia - self.get_ganancia_de_lectura()
              valores.append(round(valor - subida - de_mas, 1))

          # Las lineas que la captura no alcanza se quedan con lo que tenian
          nuevos = list(anteriores)
          cuantas = 0
          for k in range(CANTIDAD):
              if valores[k] is not None:
                  nuevos[k] = valores[k]
                  cuantas = cuantas + 1
          if cuantas == 0:
              self.set_estado_cal('NO se genero: la captura no llega a ninguna linea del peine')
              return
          self.set_medidos(nuevos)
          self.set_separacion_cal(self.get_separacion())   # la calibracion vale para la separacion actual
          try:
              guardar_calibracion()
          except Exception:
              self.set_estado_cal('NO se pudo guardar el archivo de la calibracion')
              return

          texto = 'generada a las %s con %d captura(s), %d lineas, ganancia %d dB. ' % (
              time.strftime('%H:%M:%S'), len(capturas), cuantas, ganancia)
          if len(desvios) < cuantas:
              texto = texto + 'Habia lineas sin calibrar: hacer otra pasada y repetir para verificar'
          elif max(desvios) <= TOLERANCIA and min(desvios) >= -TOLERANCIA:
              texto = texto + 'Lo leido estaba de %+.1f a %+.1f dB del objetivo: dentro de +/-%d dB' % (
                  min(desvios), max(desvios), TOLERANCIA)
          else:
              texto = texto + 'Lo leido estaba de %+.1f a %+.1f dB del objetivo: FUERA de +/-%d dB, repetir' % (
                  min(desvios), max(desvios), TOLERANCIA)
          self.set_estado_cal(texto)


      # ---------------------------------------------------------------- 2. calibracion irradiada

      def calibracion_irradiada():
          # La traza tiene que ser del peine saliendo con el objetivo actual: todas
          # las lineas calibradas por cable y ninguna sin margen
          if self.get_cargadas() < CANTIDAD or self.get_sin_margen() > 0:
              self.set_estado_irr('NO se corrigio: hace falta la calibracion conducida de las 96 lineas '
                                  'y que ninguna se quede sin margen (subir la ganancia)')
              return
          # y la calibracion conducida tiene que ser de la misma separacion que la ventana
          if self.get_separacion_cal() != 0 and self.get_separacion_cal() != self.get_separacion():
              self.set_estado_irr('NO se corrigio: la calibracion conducida es de la portadora a %g MHz '
                                  'y la ventana tiene %g MHz' % (self.get_separacion_cal(), self.get_separacion()))
              return

          con_tinysa = self.get_irradiada_tinysa() == 1
          if con_tinysa:
              elegido = Qt.QFileDialog.getOpenFileName(self, 'Elegir UNA captura de la tinySA con su antena (.csv, en dBm)',
                                                       '', 'Capturas de la tinySA (*.csv)')
          else:
              elegido = Qt.QFileDialog.getOpenFileName(self, 'Elegir UNA traza del receptor (.DAT, en dBuV/m)',
                                                       '', 'Trazas del receptor (*.DAT *.dat)')
          nombre = elegido[0]
          if nombre == '':
              return

          # La misma traza no se puede usar dos veces: duplicaria la correccion
          try:
              huella = huella_del_archivo(nombre)
          except Exception:
              self.set_estado_irr('NO se corrigio: no se pudo abrir ' + os.path.basename(nombre))
              return
          usada = traza_ya_usada(huella)
          if usada != '':
              self.set_estado_irr('NO se corrigio: esa traza ya se uso (' + usada + ')')
              return

          # Lectura: el receptor da dBuV/m. La tinySA da dBm, que se pasan a dBuV/m
          # con el factor de antena
          if con_tinysa:
              try:
                  frecuencias, niveles = leer_captura_tinysa(nombre)
              except Exception:
                  frecuencias = []
              if len(frecuencias) == 0:
                  self.set_estado_irr('NO se corrigio: no se pudo leer ' + os.path.basename(nombre))
                  return
              campos = []
              for nivel in niveles:
                  campos.append(nivel + DE_DBM_A_DBUV + self.get_factor_antena())
              cerca = CERCA_TINYSA
          else:
              try:
                  frecuencias, campos, problema = leer_traza_receptor(nombre)
              except Exception:
                  frecuencias, campos, problema = [], [], 'no se pudo leer el archivo'
              if problema != '':
                  self.set_estado_irr('NO se corrigio: ' + problema)
                  return
              cerca = CERCA_RECEPTOR

          objetivo = list(self.get_objetivo())
          correcciones = []
          sin_corregir = 0
          medido = []                                  # para el grafico: 0 si no hay dato
          for k in range(CANTIDAD):
              frecuencia = frecuencia_de_linea(k)
              pico = pico_de_la_linea(frecuencias, campos, frecuencia, cerca)
              if pico is None:
                  medido.append(0.0)
                  sin_corregir = sin_corregir + 1      # la traza no llega a esta linea
                  continue
              medido.append(round(pico, 1))
              diferencia = limite_de_la_mascara(frecuencia) - pico
              if abs(diferencia) > MAXIMA_CORRECCION:
                  sin_corregir = sin_corregir + 1      # demasiado lejos: algo no anduvo
                  continue
              objetivo[k] = round(objetivo[k] + diferencia, 1)
              correcciones.append(diferencia)

          # Lo medido queda en el grafico y en un archivo, aunque no se corrija nada
          texto = ahora() + ', ' + os.path.basename(nombre)
          if con_tinysa:
              texto = texto + ' (factor de antena %.1f dB/m)' % self.get_factor_antena()
          self.set_medido_irradiado(medido)
          try:
              escribir_archivo_de_valores(self.get_archivo_irr(), texto, medido)
          except Exception:
              pass                                     # solo es para el grafico al volver a abrir

          if len(correcciones) == 0:
              self.set_estado_irr('NO se corrigio: ninguna linea quedo a menos de %d dB del limite (%s)'
                                  % (MAXIMA_CORRECCION, texto))
              return
          # En la camara se ven todas las lineas. Si muchas quedan lejos del limite,
          # la traza es de otra cosa (otro peine, otra calibracion, el piso) y lo que
          # parece cerca es casualidad: no se aplica nada. En casa no se controla,
          # porque las lineas que quedan bajo el piso de la tinySA son esperables.
          if not con_tinysa and sin_corregir > MAXIMO_SIN_CORREGIR:
              self.set_estado_irr('NO se corrigio: %d lineas quedaron a mas de %d dB del limite. Es la traza del peine '
                                  'calibrado? (%s)' % (sin_corregir, MAXIMA_CORRECCION, texto))
              return
          try:
              guardar_respaldo(self.get_archivo_obj(), time.strftime('%Y-%m-%d_%H%M%S'))
              escribir_archivo_de_valores(self.get_archivo_obj(), 'corregido el ' + ahora() + ' con '
                                          + os.path.basename(nombre), objetivo)
          except Exception:
              self.set_estado_irr('NO se corrigio: no se pudo escribir el archivo del objetivo')
              return
          self.set_objetivo(objetivo)
          self.set_estado_obj('corregido por la irradiada a las ' + time.strftime('%H:%M:%S'))
          try:
              anotar_traza_usada(huella, nombre)
              aviso = ''
          except Exception:
              aviso = '. OJO: no se pudo anotar la traza como usada, no volver a elegirla'
          texto = texto + ': %d lineas corregidas, de %+.1f a %+.1f dB, %d sin corregir' % (
              len(correcciones), min(correcciones), max(correcciones), sin_corregir)
          if self.get_sin_margen() > 0:
              if self.get_ganancia_minima() > 55:
                  texto = texto + '. OJO: lineas sin margen: %d, y la ganancia no alcanza' % self.get_sin_margen()
              else:
                  texto = texto + '. OJO: lineas sin margen: %d, subir la ganancia a %d dB' % (
                      self.get_sin_margen(), self.get_ganancia_minima())
          self.set_estado_irr(texto + aviso)


      # ---------------------------------------------------------------- 3. patron

      def guardar_patron():
          if self.get_cargadas() < CANTIDAD:
              self.set_estado_obj('NO se guardo: primero la calibracion conducida de las 96 lineas')
              return
          elegido = Qt.QFileDialog.getOpenFileNames(self, 'Elegir la captura de la tinySA con el peine YA calibrado',
                                                    '', 'Capturas de la tinySA (*.csv)')
          nombres = elegido[0]
          if len(nombres) == 0:
              return
          capturas = leer_varias_capturas(nombres)
          if capturas is None:
              self.set_estado_obj('NO se guardo: no se pudo leer alguna de las capturas')
              return
          estimados = self.get_nivel_estimado()
          valores = []
          for k in range(CANTIDAD):
              valor = menor_de_las_capturas(capturas, k)
              if valor is None:
                  self.set_estado_obj('NO se guardo: las capturas no llegan a %d MHz' % frecuencia_de_linea(k))
                  return
              # Control: tiene que ser la captura por cable del peine que esta saliendo
              if abs(valor - estimados[k]) > 6:
                  self.set_estado_obj('NO se guardo: en %d MHz se leyo %.1f dBm y se esperaba cerca de %.1f dBm'
                                      % (frecuencia_de_linea(k), valor, estimados[k]))
                  return
              valores.append(valor)
          nombre = self.get_prefijo() + 'patron_' + time.strftime('%Y-%m-%d_%H%M') + '.txt'
          try:
              escribir_archivo_de_valores(nombre, 'patron medido por cable el ' + ahora() +
                                          ' con ganancia %d dB' % self.get_ganancia() +
                                          ', portadora %g MHz sobre la linea' % self.get_separacion() +
                                          ', tasa %g MSPS' % (self.get_samp_rate() / 1e6),
                                          valores)
          except Exception:
              self.set_estado_obj('NO se guardo: no se pudo escribir ' + nombre)
              return
          objetivo = self.get_objetivo()
          diferencias = []
          for k in range(CANTIDAD):
              diferencias.append(valores[k] - objetivo[k])
          self.set_estado_obj('patron guardado en %s. Medido menos objetivo: de %+.1f a %+.1f dB'
                              % (nombre, min(diferencias), max(diferencias)))


      def cargar_patron():
          elegido = Qt.QFileDialog.getOpenFileName(self, 'Elegir un patron guardado',
                                                   '', 'Patrones (*patron_*.txt)')
          nombre = elegido[0]
          if nombre == '':
              return
          try:
              valores = leer_archivo_de_valores(nombre)
          except Exception:
              self.set_estado_obj('NO se cargo: el archivo no tiene 96 lineas con su valor')
              return
          # El patron vale para la separacion de la portadora y la tasa con que se midio
          if es_de_otra_tasa(nombre):
              self.set_estado_obj('NO se cargo: el patron no dice la tasa de muestreo o no es la de su separacion '
                                  '(version anterior del flujo)')
              return
          portadora = numero_del_encabezado(nombre, 'portadora')
          if portadora != 0 and portadora != self.get_separacion():
              self.set_estado_obj('NO se cargo: el patron es de la portadora a %g MHz y la ventana tiene %g MHz. '
                                  'Cambiar la separacion y volver a cargarlo' % (portadora, self.get_separacion()))
              return
          ganancia = numero_del_encabezado(nombre, 'ganancia')
          try:
              guardar_respaldo(self.get_archivo_obj(), time.strftime('%Y-%m-%d_%H%M%S'))
              escribir_archivo_de_valores(self.get_archivo_obj(), 'copiado de ' + os.path.basename(nombre) +
                                          ' el ' + ahora() + ', portadora %g MHz sobre la linea' % portadora,
                                          valores)
          except Exception:
              self.set_estado_obj('NO se cargo: no se pudo escribir el archivo del objetivo')
              return
          self.set_objetivo(valores)
          self.set_estado_obj('%s cargado como objetivo. Calibrar por cable (boton 1) hasta quedar a +/-%d dB, '
                              'con ganancia %d dB como al guardarlo' % (os.path.basename(nombre), TOLERANCIA, ganancia))


      # ---------------------------------------------------------------- al abrir
      # Se carga todo lo que quedo guardado: objetivo, calibracion conducida y lo
      # medido en la ultima irradiada

      if os.path.exists(self.get_archivo_obj()):
          try:
              self.set_objetivo(leer_archivo_de_valores(self.get_archivo_obj()))
              self.set_estado_obj('cargado al abrir (' + encabezado(self.get_archivo_obj()) + ')')
          except Exception:
              self.set_estado_obj('NO se pudo leer ' + self.get_archivo_obj() + ': usar Reiniciar')
      else:
          try:
              poner_objetivo_plano('creado al abrir')
              self.set_estado_obj('no habia objetivo guardado: plano en %.1f dBm' % self.get_nivel_inicial())
          except Exception:
              self.set_estado_obj('NO se pudo escribir ' + self.get_archivo_obj())

      if os.path.exists(self.get_archivo_cal()) and es_de_otra_tasa(self.get_archivo_cal()):
          self.set_estado_cal('NO se cargo: la calibracion guardada es de otra tasa de muestreo (version anterior '
                              'del flujo). Usar Reiniciar')
      elif os.path.exists(self.get_archivo_cal()):
          try:
              self.set_medidos(leer_archivo_de_valores(self.get_archivo_cal()))
              self.set_separacion_cal(numero_del_encabezado(self.get_archivo_cal(), 'portadora'))
              self.set_estado_cal('cargada al abrir (' + encabezado(self.get_archivo_cal()).split(',')[0] + ')')
          except Exception:
              self.set_estado_cal('NO se pudo leer ' + self.get_archivo_cal() + ': usar Reiniciar')
      else:
          self.set_estado_cal('no hay ninguna: todas las lineas salen con la misma amplitud')

      if os.path.exists(self.get_archivo_irr()):
          try:
              self.set_medido_irradiado(leer_archivo_de_valores(self.get_archivo_irr()))
              self.set_estado_irr(encabezado(self.get_archivo_irr()))
          except Exception:
              self.set_estado_irr('el archivo de la ultima irradiada no se pudo leer')
      else:
          self.set_estado_irr('ninguna todavia')

      # Colores pastel en los graficos. En GRC el bloque solo ofrece colores
      # fuertes, pero desde aca acepta cualquiera. Las curvas se cuentan desde 0.
      self.grafico.set_line_color(0, '#6fa8dc')             # objetivo: azul
      self.grafico.set_line_color(1, '#93c47d')             # lo que sale: verde
      self.grafico.set_line_color(2, '#e06666')             # linea actual: rojo
      self.grafico.set_line_color(3, '#b4a7d6')             # respuesta de la placa: violeta
      self.grafico_irradiado.set_line_color(0, '#e06666')   # mascara: rojo
      self.grafico_irradiado.set_line_color(1, '#6fa8dc')   # medido: azul

      # Alto de la ventana: las filas de texto (0 a 10) quedan con lo justo y todo lo
      # que sobra va a los graficos (filas 11 a 14), que nunca bajan de 205 px. Asi
      # la ventana entra en una pantalla de 1080p con la escala en 125 %, y en una
      # pantalla mas alta los graficos crecen solos.
      # Los graficos no piden su alto preferido: si lo pidieran, con un mensaje en
      # dos renglones la ventana dejaria de entrar y apareceria una barra para bajar.
      for grafico in [self._grafico_win, self._grafico_irradiado_win]:
          grafico.setMinimumHeight(205)
          politica = grafico.sizePolicy()
          politica.setVerticalPolicy(Qt.QSizePolicy.Ignored)
          grafico.setSizePolicy(politica)
      for fila in range(11):
          self.top_grid_layout.setRowStretch(fila, 0)
      for fila in range(11, 15):
          self.top_grid_layout.setRowStretch(fila, 1)
      self.top_grid_layout.setVerticalSpacing(2)
      self.top_grid_layout.setContentsMargins(6, 4, 6, 4)

      # Letra y botones de la ventana
      self.setStyleSheet('QWidget { font-size: 10pt; } QPushButton { font-size: 11pt; min-height: 30px; }')

      # Etiquetas que no se escondan. GRC pone cada etiqueta y cada lista desplegable
      # en una barra de herramientas, y la barra esconde detras de un >> lo que no
      # entra: con la ventana en 1536 px desaparecian los mensajes largos. Aca se pasa
      # el contenido de cada barra a un renglon comun. En los tres renglones de
      # estado, que ocupan todo el ancho, un mensaje largo sigue en un segundo
      # renglon en lugar de desaparecer.
      for barra in self.findChildren(Qt.QToolBar):
          indice = self.top_grid_layout.indexOf(barra)
          if indice < 0:
              continue                                 # no esta en la grilla de la ventana
          fila, columna, alto, ancho = self.top_grid_layout.getItemPosition(indice)
          renglon = Qt.QWidget()
          disposicion = Qt.QHBoxLayout(renglon)
          disposicion.setContentsMargins(4, 0, 4, 0)
          disposicion.setSpacing(4)
          elementos = []
          for accion in barra.actions():
              if barra.widgetForAction(accion) is not None:
                  elementos.append(barra.widgetForAction(accion))
              barra.removeAction(accion)               # la barra suelta el elemento (y lo esconde)
          for elemento in elementos:
              disposicion.addWidget(elemento)
              elemento.show()
          if len(elementos) > 0 and isinstance(elementos[-1], Qt.QLabel):
              if ancho == 12:
                  elementos[-1].setWordWrap(True)      # renglon de estado: puede ocupar dos renglones
              else:
                  elementos[-1].setMinimumWidth(1)     # no obliga a ensanchar la ventana: en el peor caso se corta
              disposicion.setStretch(len(elementos) - 1, 1)
          else:
              disposicion.addStretch(1)                # una lista desplegable: queda a la izquierda
          self.top_grid_layout.removeWidget(barra)
          barra.hide()
          self.top_grid_layout.addWidget(renglon, fila, columna, alto, ancho)

      # Colores para ubicarse rapido: PAUSA en rojo, CONGELAR en azul, y los botones
      # de los tres pasos del procedimiento con un fondo de color cada uno
      for casilla in self.findChildren(Qt.QCheckBox):
          if casilla.text().startswith('PAUSA'):
              casilla.setStyleSheet('color: #c0392b; font-weight: bold;')
          if casilla.text().startswith('CONGELAR'):
              casilla.setStyleSheet('color: #2e86c1; font-weight: bold;')
      for boton in self.findChildren(Qt.QPushButton):
          if boton.text().startswith('1.'):
              boton.setStyleSheet('background-color: #d6e6f5;')     # azul pastel
          if boton.text().startswith('2.'):
              boton.setStyleSheet('background-color: #d9ead3;')     # verde pastel
          if boton.text().startswith('3.') or boton.text().startswith('Cargar'):
              boton.setStyleSheet('background-color: #fff2cc;')     # amarillo pastel
          if boton.text().startswith('Reiniciar'):
              boton.setStyleSheet('background-color: #f4cccc;')     # rojo pastel


      # ---------------------------------------------------------------- botones
      # GNU Radio llama a set_boton_...(1) cuando se aprieta un boton y a
      # set_boton_...(0) cuando se suelta. Aca se define que hace esa llamada. Todos
      # actuan al soltar el boton: si actuaran al apretarlo, el boton quedaria
      # hundido mientras la ventana para elegir archivos esta abierta.
      def al_tocar_reiniciar(valor):
          if valor == 0:
              reiniciar()


      def al_tocar_conducida(valor):
          if valor == 0:
              generar_conducida()


      def al_tocar_irradiada(valor):
          if valor == 0:
              calibracion_irradiada()


      def al_tocar_guardar_patron(valor):
          if valor == 0:
              guardar_patron()


      def al_tocar_cargar_patron(valor):
          if valor == 0:
              cargar_patron()


      self.set_boton_reiniciar = al_tocar_reiniciar
      self.set_boton_conducida = al_tocar_conducida
      self.set_boton_irradiada = al_tocar_irradiada
      self.set_boton_guardar_patron = al_tocar_guardar_patron
      self.set_boton_cargar_patron = al_tocar_cargar_patron


      # ============================================================================
      # NO RESINTONIZAR DE MAS
      # El paso del barrido cambia 10 veces por segundo y GNU Radio vuelve a mandar la
      # frecuencia a la placa en cada cambio, aunque sea la misma. La placa
      # resintoniza igual, y eso con el tono encendido lo perturba. Aca se hace que
      # la frecuencia se mande solo cuando cambia.
      # ============================================================================
      mandar_frecuencia = self.set_freq


      def mandar_frecuencia_si_cambia(frecuencia):
          if frecuencia != self.get_freq():
              mandar_frecuencia(frecuencia)


      self.set_freq = mandar_frecuencia_si_cambia


      # ============================================================================
      # CONGELAR EL BARRIDO
      # Mientras la casilla CONGELAR esta tildada, el paso del barrido no avanza: la
      # placa se queda en la linea que estaba saliendo. (El flujo, por su lado, deja
      # el tono encendido mientras este congelado.)
      # ============================================================================
      avanzar_paso = self.set_paso


      def avanzar_paso_si_no_esta_congelado(valor):
          if self.get_congelar() == 0:
              avanzar_paso(valor)
          else:
              # se devuelve el numero a la lista: al destildar, el barrido sigue donde estaba
              self.get_lista_de_pasos().append(valor)


      self.set_paso = avanzar_paso_si_no_esta_congelado
  states: {}
- name: nivel_inicial
  id: variable_qtgui_range
  parameters:
    comment: |-
      Objetivo plano que deja el boton Reiniciar.
      Solo actua al reiniciar
    gui_hint: 2,9,1,3
    label: Nivel al reiniciar (dBm)
    min_len: '50'
    start: '-50'
    step: '0.5'
    stop: '-10'
    value: '-33'
    widget: counter
  states: {}
- name: irradiada_tinysa
  id: variable
  parameters:
    comment: |-
      1: la irradiada lee capturas .csv de la
      tinySA (version de casa). 0: trazas .DAT del
      receptor
    value: '0'
  states: {}
- name: factor_antena
  id: variable
  parameters:
    comment: Solo se usa en la version de casa
    value: '0'
  states: {}
- name: boton_reiniciar
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 7,0,1,4
    label: Reiniciar calibracion
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: boton_cargar_patron
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 7,8,1,4
    label: Cargar patron
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: et_mascara
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt; color:" + (''black'') + "''><b>" + str(x) + "</b></span>"'
    gui_hint: 7,4,1,4
    label: '<span style=''font-size:11pt''>Mascara: </span>'
    type: string
    value: '''CISPR 11 G1 clase A (50 y 57 dBuV/m)'''
  states: {}
- name: ritmo_simulacion
  id: blocks_throttle2
  parameters:
    comment: |-
      Sin la placa, esto marca el ritmo de las
      muestras (1 MSPS alcanza: no van a ningun lado)
    samples_per_second: 1e6
    type: complex
  states: {}
- name: salida_nula
  id: blocks_null_sink
  parameters:
    comment: |-
      SIN PLACA: las muestras se tiran aca. No se
      abre ni se usa ningun dispositivo
    type: complex
  states: {}

connections:
- [datos_obj, '0', ritmo_grafico, '0']
- [ritmo_grafico, '0', grafico, '0']
- [datos_est, '0', grafico, '1']
- [datos_actual, '0', grafico, '2']
- [datos_resp, '0', grafico, '3']
- [datos_mascara, '0', ritmo_grafico_2, '0']
- [ritmo_grafico_2, '0', grafico_irradiado, '0']
- [datos_irr, '0', grafico_irradiado, '1']
- [tono, '0', ritmo_simulacion, '0']
- [ritmo_simulacion, '0', salida_nula, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
