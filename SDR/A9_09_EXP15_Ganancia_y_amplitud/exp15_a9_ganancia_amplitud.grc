options:
  parameters:
    description: 'bladeRF 2.0 micro xA9: portadora en 100 MHz, tono a 200 kHz, ganancia y amplitud ajustables en forma fina'
    generate_options: qt_gui
    id: exp15_a9_ganancia_amplitud
    output_language: python
    title: 'EXP-15 xA9: ganancia y amplitud'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Tasa de muestreo
    value: 2e6
  states: {}
- name: freq
  id: variable
  parameters:
    comment: Portadora
    value: 100e6
  states: {}
- name: f_tono
  id: variable
  parameters:
    comment: El tono sale en freq + f_tono
    value: 200e3
  states: {}
- name: tope
  id: variable_qtgui_chooser
  parameters:
    comment: Limita la ganancia aunque el deslizador este mas arriba
    gui_hint: 0,0,1,3
    label: Tope de seguridad de la ganancia
    num_opts: '5'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
    option0: '0'
    label0: 0 dB
    option1: '20'
    label1: 20 dB
    option2: '40'
    label2: 40 dB
    option3: '55'
    label3: 55 dB
    option4: '66'
    label4: 66 dB (maximo)
  states: {}
- name: ganancia
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,3
    label: Ganancia pedida (dB)
    min_len: '400'
    start: '-23.75'
    step: '0.25'
    stop: '66'
    value: '0'
  states: {}
- name: amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,3
    label: Amplitud del tono (0 a 1)
    min_len: '400'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: et_ganancia
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: (''%.2f dB'' % x)'
    gui_hint: 3,0,1,1
    label: 'Ganancia aplicada: '
    type: real
    value: tx_gain
  states: {}
- name: et_limite
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''LIMITANDO'' if x else ''sin limitar'''
    gui_hint: 3,1,1,1
    label: 'Tope: '
    type: real
    value: 1 if ganancia > tope else 0
  states: {}
- name: et_amp
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.2f'' % x'
    gui_hint: 3,2,1,1
    label: 'Amplitud: '
    type: real
    value: amp
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: 'Ganancia que se le manda a la placa: nunca supera el tope'
    value: min(ganancia, tope)
  states: {}
- name: aspecto
  id: snippet
  parameters:
    comment: Letra grande en las etiquetas de estado
    section: main_after_init
    code: |
      # Las etiquetas de GNU Radio no tienen tamano de letra: se lo cambiamos aca.
      for nombre in ('et_ganancia', 'et_limite', 'et_amp'):
          barra = getattr(self, '_%s_tool_bar' % nombre)
          ancho = 60
          for accion in barra.actions():
              etiqueta = barra.widgetForAction(accion)
              etiqueta.setStyleSheet('font-size: 15pt; font-weight: bold')
              ancho += etiqueta.sizeHint().width()
          barra.setMinimumWidth(ancho + 60)
      self.resize(self.top_widget.minimumSizeHint().width() + 60, 330)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: f_tono
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=321e0fa5875945d99b11070bb0a76d31
    bb_gain0: '0'
    bw0: 1.5e6
    freq0: freq
    gain0: tx_gain
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
