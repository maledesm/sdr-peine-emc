options:
  parameters:
    description: Peine por tandas de 300 a 510 MHz, calibracion de la placa al arrancar y una amplitud elegible por tono (ecualizador). Ganancia fija en 30
    generate_options: qt_gui
    id: exp14_peine_ecualizado
    output_language: python
    title: EXP-14 peine calibrado con ecualizador
  states: {}

blocks:
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Tasa de muestreo. Requiere USB 3
    value: 20e6
  states: {}
- name: f_tono
  id: variable
  parameters:
    comment: Los dos tonos van en +f_tono y -f_tono
    value: 5e6
  states: {}
- name: tasa_ctrl
  id: variable
  parameters:
    comment: Tasa de la rama de control del barrido
    value: 10e3
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: Ganancia de transmision fija. La tabla de fuga vale solo para esta ganancia
    value: '30'
  states: {}
- name: portadoras
  id: variable
  parameters:
    comment: 11 portadoras, de 305 a 505 MHz
    value: '[305e6 + 20e6*i for i in range(11)]'
  states: {}
- name: modo
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,6
    label: Modo
    num_opts: '2'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
    option0: '0'
    label0: Automatico
    option1: '1'
    label1: Manual
  states: {}
- name: portadora_manual
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,6,1,6
    label: Portadora en modo manual
    labels: '[''305 MHz'', ''325 MHz'', ''345 MHz'', ''365 MHz'', ''385 MHz'', ''405 MHz'', ''425 MHz'', ''445 MHz'', ''465 MHz'', ''485 MHz'', ''505 MHz'']'
    options: '[305000000, 325000000, 345000000, 365000000, 385000000, 405000000, 425000000, 445000000, 465000000, 485000000, 505000000]'
    num_opts: '0'
    type: real
    value: '305000000'
  states: {}
- name: permanencia
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,12,1,11
    label: Permanencia por portadora (s)
    min_len: '250'
    start: '1'
    step: '0.5'
    stop: '20'
    value: '2'
  states: {}
- name: et_portadora
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 1,0,1,5
    label: 'Portadora: '
    type: real
    value: freq / 1e6
  states: {}
- name: et_inferior
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 1,5,1,5
    label: 'Inferior: '
    type: real
    value: (freq - f_tono) / 1e6
  states: {}
- name: et_superior
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 1,10,1,5
    label: 'Superior: '
    type: real
    value: (freq + f_tono) / 1e6
  states: {}
- name: et_paso
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%d de 11'' % x'
    gui_hint: 1,15,1,3
    label: 'Paso: '
    type: real
    value: indice_activo + 1
  states: {}
- name: et_pico
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: (''%.2f'' % x) if x <= 1 else (''%.2f RECORTA'' % x)'
    gui_hint: 1,18,1,5
    label: 'Pico: '
    type: real
    value: a_inf + a_sup
  states: {}
- name: indice_medido
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    comment: Lee la escalera de la rama de control
    function_name: level
    poll_rate: '2'
    value: '0'
  states: {}
- name: indice
  id: variable
  parameters:
    comment: Paso del barrido automatico, desde 0
    value: min(max(int(round(indice_medido)), 0), len(portadoras) - 1)
  states: {}
- name: indice_activo
  id: variable
  parameters:
    comment: 'Portadora en uso: la manual o la del barrido'
    value: int(round((portadora_manual - portadoras[0]) / 20e6)) if modo == 1 else indice
  states: {}
- name: freq
  id: variable
  parameters:
    comment: Frecuencia del oscilador
    value: portadoras[indice_activo]
  states: {}
- name: amps_inf
  id: variable
  parameters:
    comment: Amplitudes de los tonos inferiores
    value: '[amp_300, amp_320, amp_340, amp_360, amp_380, amp_400, amp_420, amp_440, amp_460, amp_480, amp_500]'
  states: {}
- name: amps_sup
  id: variable
  parameters:
    comment: Amplitudes de los tonos superiores
    value: '[amp_310, amp_330, amp_350, amp_370, amp_390, amp_410, amp_430, amp_450, amp_470, amp_490, amp_510]'
  states: {}
- name: a_inf
  id: variable
  parameters:
    comment: Amplitud del tono inferior de la portadora en uso
    value: amps_inf[indice_activo]
  states: {}
- name: a_sup
  id: variable
  parameters:
    comment: Amplitud del tono superior de la portadora en uso
    value: amps_sup[indice_activo]
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_tono
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_sup
  id: blocks_multiply_const_vxx
  parameters:
    const: a_sup
    type: complex
  states: {}
- name: blocks_multiply_const_inf
  id: blocks_multiply_const_vxx
  parameters:
    const: a_inf
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=0
    bb_gain0: '0'
    bw0: 14e6
    freq0: freq
    gain0: tx_gain
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: list(range(len(portadoras)))
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(permanencia * tasa_ctrl)
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '0.05'
    samples_per_second: tasa_ctrl
    type: float
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: calibrar_lms
  id: variable
  parameters:
    comment: 'True: corre calibrate lms al arrancar'
    value: 'True'
  states: {}
- name: generar_tabla
  id: variable
  parameters:
    comment: 'True: genera la tabla de fuga. False: usa la de una corrida anterior'
    value: 'True'
  states: {}
- name: ganancia_tabla
  id: variable
  parameters:
    comment: Ganancia con la que se genera la tabla. Tiene que ser la del peine
    value: tx_gain
  states: {}
- name: calibracion
  id: snippet
  parameters:
    comment: Calibra la placa con bladeRF-cli antes de abrirla
    code: |
      # Corre ANTES de que el osmocom Sink abra la placa, cuando todavia esta libre.
      # Deja instalada la tabla de fuga: la biblioteca de la placa la carga sola y la aplica en cada sintonia.
      import os, shutil, subprocess, time

      cli = r"C:\Program Files\bladeRF\x64\bladeRF-cli.exe"
      carpeta = os.path.dirname(os.path.abspath(__file__))
      destino = os.path.join(os.environ["APPDATA"], "Nuand", "bladeRF")    # donde la biblioteca busca las tablas

      def correr(comandos):
          """Ejecuta comandos de bladeRF-cli y muestra la salida en la consola."""
          args = [cli]
          for c in comandos:
              args += ["-e", c]
          p = subprocess.Popen(args, cwd=carpeta, stdout=subprocess.PIPE, stderr=subprocess.STDOUT, text=True)
          for linea in p.stdout:
              print("   [bladeRF-cli] " + linea.rstrip())
          p.wait()

      print("=== EXP-14: calibracion antes de transmitir ===")
      t_inicio = time.time()
      os.makedirs(destino, exist_ok=True)

      if self.calibrar_lms:
          print("1) calibrate lms")
          correr(["calibrate lms"])

      if self.generar_tabla:
          print("2) Generando la tabla de fuga para las portadoras del peine.")
          for f in os.listdir(carpeta):                       # borrar tablas de corridas anteriores
              if f.endswith("_dc_tx.tbl"):
                  os.remove(os.path.join(carpeta, f))
          f_min = "%dM" % round(min(self.portadoras) / 1e6)
          f_max = "%dM" % round(max(self.portadoras) / 1e6)
          correr(["set gain tx1 %d" % self.ganancia_tabla, "calibrate table dc tx %s %s 20M" % (f_min, f_max)])
          for f in os.listdir(carpeta):
              if f.endswith("_dc_tx.tbl"):
                  shutil.copyfile(os.path.join(carpeta, f), os.path.join(destino, f))

      # Si una corrida anterior dejo la tabla desactivada y no hay una activa, volver a activarla.
      for f in os.listdir(destino):
          if f.endswith("_dc_tx.tbl.desactivada"):
              activa = os.path.join(destino, f[:-len(".desactivada")])
              if os.path.isfile(activa):
                  os.remove(os.path.join(destino, f))
              else:
                  os.replace(os.path.join(destino, f), activa)

      instaladas = [f for f in os.listdir(destino) if f.endswith("_dc_tx.tbl")]
      print("3) Tabla de fuga instalada: " + (", ".join(instaladas) or "NINGUNA"))
      print("=== Fin de la calibracion ===")

      lineas = ["Calibracion terminada en %.0f segundos." % (time.time() - t_inicio), "",
                "calibrate lms: " + ("ejecutada" if self.calibrar_lms else "omitida"),
                "Tabla de fuga: " + ("generada ahora" if self.generar_tabla else "la de una corrida anterior"),
                "Tabla instalada: " + ("si" if instaladas else "NO HAY NINGUNA"),
                "", "Al aceptar se abre la placa y empieza a transmitir."]
      try:
          import winsound
          for _ in range(3):
              winsound.Beep(1000, 250)
      except Exception:
          pass
      try:
          Qt.QMessageBox.information(None, "EXP-14: calibracion terminada", chr(10).join(lineas))
      except Exception as e:
          print("No se pudo mostrar el cartel: %s" % e)
      print("=== Abriendo la placa para transmitir ===")
    section: init_before_blocks
  states: {}
- name: aspecto
  id: snippet
  parameters:
    comment: Letra grande y selectores compactos
    section: main_after_init
    code: |
      # Ajustes de aspecto que los bloques de GNU Radio no permiten configurar.
      # 1) Etiquetas de estado con letra grande, y con ancho minimo para que no se corten.
      extra = {'et_pico': 130, 'et_paso': 30}
      for nombre in ('et_portadora', 'et_inferior', 'et_superior', 'et_paso', 'et_pico'):
          barra = getattr(self, '_%s_tool_bar' % nombre)
          ancho = 30 + extra.get(nombre, 0)
          for accion in barra.actions():
              etiqueta = barra.widgetForAction(accion)
              etiqueta.setStyleSheet('font-size: 15pt; font-weight: bold')
              ancho += etiqueta.sizeHint().width()
          barra.setMinimumWidth(ancho)
      # 2) Selectores de amplitud: sin su etiqueta propia (la frecuencia esta en la fila de arriba) y sin cortarse.
      for f in range(300, 511, 10):
          barra = getattr(self, '_amp_%d_tool_bar' % f)
          barra.actions()[0].setVisible(False)
          selector = getattr(self, '_amp_%d_combo_box' % f)
          selector.setFixedWidth(56)
          barra.setMinimumWidth(62)
      # 3) Menos espacio entre columnas y tamano inicial de la ventana segun su contenido.
      self.top_grid_layout.setHorizontalSpacing(2)
      self.resize(self.top_widget.minimumSizeHint().width() + 50, 270)
  states: {}
- name: enc_mhz
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,1
    label: MHz
    type: string
    value: ''''''
  states: {}
- name: enc_amp
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,0,1,1
    label: Amplitud
    type: string
    value: ''''''
  states: {}
- name: enc_300
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,1,1,1
    label: '300'
    type: string
    value: ''''''
  states: {}
- name: amp_300
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,1,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_310
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,2,1,1
    label: '310'
    type: string
    value: ''''''
  states: {}
- name: amp_310
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,2,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_320
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,3,1,1
    label: '320'
    type: string
    value: ''''''
  states: {}
- name: amp_320
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,3,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_330
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,4,1,1
    label: '330'
    type: string
    value: ''''''
  states: {}
- name: amp_330
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,4,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_340
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,5,1,1
    label: '340'
    type: string
    value: ''''''
  states: {}
- name: amp_340
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,5,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_350
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,6,1,1
    label: '350'
    type: string
    value: ''''''
  states: {}
- name: amp_350
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,6,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_360
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,7,1,1
    label: '360'
    type: string
    value: ''''''
  states: {}
- name: amp_360
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,7,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_370
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,8,1,1
    label: '370'
    type: string
    value: ''''''
  states: {}
- name: amp_370
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,8,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_380
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,9,1,1
    label: '380'
    type: string
    value: ''''''
  states: {}
- name: amp_380
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,9,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_390
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,10,1,1
    label: '390'
    type: string
    value: ''''''
  states: {}
- name: amp_390
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,10,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_400
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,11,1,1
    label: '400'
    type: string
    value: ''''''
  states: {}
- name: amp_400
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,11,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_410
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,12,1,1
    label: '410'
    type: string
    value: ''''''
  states: {}
- name: amp_410
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,12,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_420
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,13,1,1
    label: '420'
    type: string
    value: ''''''
  states: {}
- name: amp_420
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,13,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_430
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,14,1,1
    label: '430'
    type: string
    value: ''''''
  states: {}
- name: amp_430
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,14,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_440
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,15,1,1
    label: '440'
    type: string
    value: ''''''
  states: {}
- name: amp_440
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,15,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_450
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,16,1,1
    label: '450'
    type: string
    value: ''''''
  states: {}
- name: amp_450
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,16,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_460
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,17,1,1
    label: '460'
    type: string
    value: ''''''
  states: {}
- name: amp_460
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,17,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_470
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,18,1,1
    label: '470'
    type: string
    value: ''''''
  states: {}
- name: amp_470
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,18,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_480
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,19,1,1
    label: '480'
    type: string
    value: ''''''
  states: {}
- name: amp_480
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,19,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_490
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,20,1,1
    label: '490'
    type: string
    value: ''''''
  states: {}
- name: amp_490
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,20,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_500
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,21,1,1
    label: '500'
    type: string
    value: ''''''
  states: {}
- name: amp_500
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,21,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}
- name: enc_510
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,22,1,1
    label: '510'
    type: string
    value: ''''''
  states: {}
- name: amp_510
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,22,1,1
    label: ' '
    labels: '[''0.10'', ''0.15'', ''0.20'', ''0.25'', ''0.30'', ''0.35'', ''0.40'', ''0.45'', ''0.50'', ''0.55'', ''0.60'', ''0.65'', ''0.70'']'
    options: '[0.10, 0.15, 0.20, 0.25, 0.30, 0.35, 0.40, 0.45, 0.50, 0.55, 0.60, 0.65, 0.70]'
    num_opts: '0'
    type: real
    value: '0.4'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_sup, '0']
- [analog_sig_source_x_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_const_inf, '0']
- [blocks_multiply_const_sup, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_inf, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_probe_signal_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
