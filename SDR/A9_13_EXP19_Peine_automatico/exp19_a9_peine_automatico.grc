options:
  parameters:
    description: 'bladeRF 2.0 micro xA9: peine de 70 a 420 MHz, lineas cada 10 MHz. El receptor de la propia placa mide cada linea por cable y el flujo corrige la amplitud de cada tono hasta dejarlas iguales. Despues transmite'
    generate_options: qt_gui
    id: exp19_a9_peine_automatico
    output_language: python
    title: 'EXP-19 xA9: peine por tandas con calibracion automatica'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Tasa de muestreo, comun a TX y RX. En esta
      PC no pasar de 25e6
    value: 20e6
  states: {}
- name: f_tono
  id: variable
  parameters:
    comment: |-
      Cada portadora lleva dos tonos: en +f_tono y
      en -f_tono
    value: 5e6
  states: {}
- name: amp
  id: variable
  parameters:
    comment: |-
      Amplitud de un tono sin corregir. La suma de
      los dos no debe pasar de 0.95
    value: '0.45'
  states: {}
- name: ancho_banda
  id: variable
  parameters:
    comment: Filtro analogico de la placa, en TX y en RX
    value: 18e6
  states: {}
- name: tope
  id: variable
  parameters:
    comment: |-
      Tope de seguridad de la ganancia de TX con
      el cable al receptor: con 30 dB salen unos
      -27 dBm como maximo
    value: '30'
  states: {}
- name: f_primera
  id: variable
  parameters:
    comment: |-
      Primera portadora. Sus lineas salen en 70 y
      80 MHz
    value: 75e6
  states: {}
- name: paso_port
  id: variable
  parameters:
    comment: Separacion entre portadoras
    value: 20e6
  states: {}
- name: n_port
  id: variable
  parameters:
    comment: |-
      Cantidad de portadoras: 18 dan 36 lineas, de
      70 a 420 MHz
    value: '18'
  states: {}
- name: respuesta_rx
  id: variable
  parameters:
    comment: |-
      Cuantos dB de mas lee el RX en cada linea
      (70, 80, ... 420 MHz). Queda en cero hasta
      compararlo con un analizador
    value: '[0.0] * 36'
  states: {}
- name: decim
  id: variable
  parameters:
    comment: El filtro de cada tono baja la tasa a 1 MSPS
    value: int(samp_rate / 1e6)
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: Pasabajos que deja solo el tono elegido
    gain: '1.0'
    samp_rate: samp_rate
    cutoff_freq: 100e3
    width: 400e3
    win: window.WIN_HAMMING
  states: {}
- name: largo_promedio
  id: variable
  parameters:
    comment: 'Muestras que se promedian: 0,1 s a 1 MSPS'
    value: '100000'
  states: {}
- name: nivel_inf
  id: variable_function_probe
  parameters:
    block_id: sonda_inf
    comment: |-
      Nivel del tono inferior leido por el RX, en
      dB
    function_name: level
    poll_rate: '10'
    value: '-120'
  states: {}
- name: nivel_sup
  id: variable_function_probe
  parameters:
    block_id: sonda_sup
    comment: |-
      Nivel del tono superior leido por el RX, en
      dB
    function_name: level
    poll_rate: '10'
    value: '-120'
  states: {}
- name: indice
  id: variable
  parameters:
    comment: |-
      Portadora actual, de 0 a n_port - 1. La
      cambia la receta
    value: '0'
  states: {}
- name: silencio
  id: variable
  parameters:
    comment: |-
      1: tonos apagados. 0: tonos encendidos. Lo
      cambia la receta
    value: '1'
  states: {}
- name: correcciones
  id: variable
  parameters:
    comment: |-
      Correccion de cada linea, en dB (0 o
      negativa). Las calcula la receta
    value: '[0.0] * 36'
  states: {}
- name: etapa
  id: variable
  parameters:
    comment: |-
      Texto de la etapa actual. Lo cambia la
      receta
    value: '''INICIACION'''
  states: {}
- name: pasadas
  id: variable
  parameters:
    comment: Pasadas completas del peine en transmision
    value: '0'
  states: {}
- name: desvio_antes
  id: variable
  parameters:
    comment: |-
      Cuanto sobresalia cada linea antes de
      corregir, en dB
    value: '[0.0] * 36'
  states: {}
- name: desvio_despues
  id: variable
  parameters:
    comment: |-
      Cuanto se aparta cada linea despues de
      corregir, en dB
    value: '[0.0] * 36'
  states: {}
- name: resultado
  id: variable
  parameters:
    comment: Resumen de la ultima calibracion
    value: '''todavia sin calibrar'''
  states: {}
- name: orden
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,4
    label: Orden
    labels: '[''Esperar (sin emitir)'', ''Calibrar (cable de TX1 a RX1)'', ''Transmitir el peine'']'
    options: '[0, 1, 2]'
    num_opts: '0'
    type: int
    value: '0'
  states: {}
- name: ganancia_base
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,4,1,3
    label: Ganancia de TX
    labels: '[''0 dB'', ''10 dB'', ''20 dB'', ''30 dB'']'
    options: '[0, 10, 20, 30]'
    num_opts: '0'
    type: int
    value: '30'
  states: {}
- name: permanencia
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,7,1,3
    label: Permanencia por portadora
    labels: '[''0,5 s'', ''1 s'', ''2 s'', ''3 s'', ''5 s'']'
    options: '[0.5, 1, 2, 3, 5]'
    num_opts: '0'
    type: real
    value: '1'
  states: {}
- name: rx_gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,10,1,2
    label: Ganancia de RX
    labels: '[''0 dB'', ''10 dB'', ''20 dB'', ''30 dB'', ''40 dB'', ''50 dB'', ''60 dB'']'
    options: '[0, 10, 20, 30, 40, 50, 60]'
    num_opts: '0'
    type: int
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: |-
      Frecuencia de la portadora actual, en TX y
      en RX
    value: f_primera + paso_port * indice
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: |-
      Ganancia que recibe la placa: nunca supera
      el tope
    value: min(ganancia_base, tope)
  states: {}
- name: c_inf
  id: variable
  parameters:
    comment: |-
      Correccion de la linea inferior actual, en
      dB
    value: correcciones[2 * indice]
  states: {}
- name: c_sup
  id: variable
  parameters:
    comment: |-
      Correccion de la linea superior actual, en
      dB
    value: correcciones[2 * indice + 1]
  states: {}
- name: amp_inf
  id: variable
  parameters:
    comment: Amplitud del tono inferior ya corregida
    value: 0 if silencio == 1 else amp * 10 ** (c_inf / 20)
  states: {}
- name: amp_sup
  id: variable
  parameters:
    comment: Amplitud del tono superior ya corregida
    value: 0 if silencio == 1 else amp * 10 ** (c_sup / 20)
  states: {}
- name: et_etapa
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:16pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,0,1,12
    label: '<span style=''font-size:16pt''>Etapa: </span>'
    type: string
    value: etapa
  states: {}
- name: et_portadora
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:13pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 2,0,1,4
    label: '<span style=''font-size:13pt''>Portadora: </span>'
    type: string
    value: '''%d de %d, en %.0f MHz'' % (indice + 1, n_port, freq / 1e6)'
  states: {}
- name: et_lineas
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:13pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 2,4,1,4
    label: '<span style=''font-size:13pt''>Lineas: </span>'
    type: string
    value: '''%.0f y %.0f MHz'' % ((freq - f_tono) / 1e6, (freq + f_tono) / 1e6)'
  states: {}
- name: et_pasadas
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:13pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 2,8,1,4
    label: '<span style=''font-size:13pt''>Pasadas completas: </span>'
    type: int
    value: pasadas
  states: {}
- name: et_amp
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 3,0,1,4
    label: '<span style=''font-size:11pt''>Amplitudes: </span>'
    type: string
    value: '''%.3f y %.3f'' % (amp_inf, amp_sup)'
  states: {}
- name: et_rx
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 3,4,1,4
    label: '<span style=''font-size:11pt''>El RX lee ahora: </span>'
    type: string
    value: '''%.1f y %.1f dB'' % (nivel_inf, nivel_sup)'
  states: {}
- name: et_resultado
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 3,8,1,4
    label: '<span style=''font-size:11pt''>Planitud segun el RX: </span>'
    type: string
    value: resultado
  states: {}
- name: et_tabla
  id: variable_qtgui_label
  parameters:
    gui_hint: 5,0,1,12
    label: 'Correcciones en dB, de 70 a 420 MHz: '
    type: string
    value: ''', ''.join([''%.1f'' % c for c in correcciones])'
  states: {}
- name: tono_superior
  id: analog_sig_source_x
  parameters:
    comment: Sale en portadora + 5 MHz
    amp: amp_sup
    freq: f_tono
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: tono_inferior
  id: analog_sig_source_x
  parameters:
    comment: Sale en portadora - 5 MHz
    amp: amp_inf
    freq: '-f_tono'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: suma
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=321e0fa5875945d99b11070bb0a76d31
    bb_gain0: '0'
    bw0: ancho_banda
    comment: bladeRF 2.0 micro xA9, salida TX1
    freq0: freq
    gain0: tx_gain
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    comment: |-
      bladeRF 2.0 micro xA9, entrada RX1. Ganancia
      manual
    type: fc32
    args: bladerf=321e0fa5875945d99b11070bb0a76d31
    sync: sync
    sample_rate: samp_rate
    freq0: freq
    gain_mode0: 'False'
    gain0: rx_gain
    if_gain0: '0'
    bb_gain0: '0'
    bw0: ancho_banda
  states: {}
- name: filtro_sup
  id: freq_xlating_fir_filter_xxx
  parameters:
    comment: Deja solo el tono de +5 MHz
    type: ccf
    decim: decim
    taps: taps
    center_freq: f_tono
    samp_rate: samp_rate
  states: {}
- name: potencia_sup
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Potencia instantanea
  states: {}
- name: promedio_sup
  id: blocks_moving_average_xx
  parameters:
    comment: Promedia los ultimos 0,1 s
    type: float
    length: largo_promedio
    scale: 1.0 / largo_promedio
    max_iter: '4000'
  states: {}
- name: a_db_sup
  id: blocks_nlog10_ff
  parameters:
    comment: 'Pasa a dB: 10 log10'
    n: '10'
    k: '0'
  states: {}
- name: sonda_sup
  id: blocks_probe_signal_x
  parameters:
    comment: Deja leer el valor desde un Function Probe
    type: float
  states: {}
- name: filtro_inf
  id: freq_xlating_fir_filter_xxx
  parameters:
    comment: Deja solo el tono de -5 MHz
    type: ccf
    decim: decim
    taps: taps
    center_freq: '-f_tono'
    samp_rate: samp_rate
  states: {}
- name: potencia_inf
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Potencia instantanea
  states: {}
- name: promedio_inf
  id: blocks_moving_average_xx
  parameters:
    comment: Promedia los ultimos 0,1 s
    type: float
    length: largo_promedio
    scale: 1.0 / largo_promedio
    max_iter: '4000'
  states: {}
- name: a_db_inf
  id: blocks_nlog10_ff
  parameters:
    comment: 'Pasa a dB: 10 log10'
    n: '10'
    k: '0'
  states: {}
- name: sonda_inf
  id: blocks_probe_signal_x
  parameters:
    comment: Deja leer el valor desde un Function Probe
    type: float
  states: {}
- name: linea_de_punto
  id: variable
  parameters:
    comment: |-
      Los graficos tienen 256 puntos, 7 por linea:
      a que linea (0 a 35) corresponde cada punto
    value: '[min(j // 7, 2 * n_port - 1) for j in range(256)]'
  states: {}
- name: curva_antes
  id: variable
  parameters:
    comment: Desvio antes de corregir
    value: '[desvio_antes[k] for k in linea_de_punto]'
  states: {}
- name: datos_curva_antes
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: curva_antes
    vlen: '256'
  states: {}
- name: curva_despues
  id: variable
  parameters:
    comment: Desvio despues de corregir
    value: '[desvio_despues[k] for k in linea_de_punto]'
  states: {}
- name: datos_curva_despues
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: curva_despues
    vlen: '256'
  states: {}
- name: ritmo_grafico_medicion
  id: blocks_throttle2
  parameters:
    comment: Solo marca el ritmo del grafico
    limit: time
    maximum: '0.01'
    samples_per_second: '2000'
    type: float
    vlen: '256'
  states: {}
- name: grafico_medicion
  id: qtgui_vector_sink_f
  parameters:
    name: '"Lo que midio el RX: cuanto sobresale cada linea"'
    vlen: '256'
    x_start: (f_primera - f_tono) / 1e6 - 5
    x_step: 10.0 / 7
    x_axis_label: '"Frecuencia de la linea"'
    y_axis_label: '"Desvio"'
    x_units: '"MHz"'
    y_units: '"dB"'
    grid: 'True'
    ymin: '-2'
    nconnections: '2'
    gui_hint: 4,0,1,6
    label1: '"Antes de corregir"'
    width1: '2'
    color1: '"red"'
    label2: '"Despues de corregir"'
    width2: '3'
    color2: '"dark green"'
  states: {}
- name: curva_correccion
  id: variable
  parameters:
    comment: Correccion de cada linea
    value: '[correcciones[k] for k in linea_de_punto]'
  states: {}
- name: datos_curva_correccion
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: curva_correccion
    vlen: '256'
  states: {}
- name: curva_actual
  id: variable
  parameters:
    comment: Marca las dos lineas que salen ahora
    value: '[(correcciones[k] if (k // 2 == indice and silencio == 0) else -11) for k in linea_de_punto]'
  states: {}
- name: datos_curva_actual
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: curva_actual
    vlen: '256'
  states: {}
- name: ritmo_grafico_correccion
  id: blocks_throttle2
  parameters:
    comment: Solo marca el ritmo del grafico
    limit: time
    maximum: '0.01'
    samples_per_second: '2000'
    type: float
    vlen: '256'
  states: {}
- name: grafico_correccion
  id: qtgui_vector_sink_f
  parameters:
    name: '"Correccion aplicada a cada linea"'
    vlen: '256'
    x_start: (f_primera - f_tono) / 1e6 - 5
    x_step: 10.0 / 7
    x_axis_label: '"Frecuencia de la linea"'
    y_axis_label: '"Correccion"'
    x_units: '"MHz"'
    y_units: '"dB"'
    grid: 'True'
    ymin: '-11'
    ymax: '1'
    nconnections: '2'
    gui_hint: 4,6,1,6
    label1: '"Correccion de cada linea"'
    width1: '2'
    label2: '"Lineas que salen ahora"'
    width2: '3'
  states: {}
- name: receta
  id: snippet
  parameters:
    comment: |-
      Secuencia del peine: esperar, calibrar o
      transmitir
    section: main_after_init
    code: |
      # ============================================================================
      # RECETA DEL PEINE AUTOMATICO
      # Este codigo corre al mismo tiempo que el flujo. Hace lo que se elija en
      # "Orden" en la ventana: esperar, calibrar o transmitir.
      # Usa solo las variables del flujo: las lee con self.get_...() y las cambia
      # con self.set_...(). Generar los tonos, medir y mostrar lo hacen los bloques.
      # ============================================================================
      import time
      import threading

      ESPERA_SILENCIO = 0.3      # segundos con los tonos apagados antes de cada salto
      ESPERA_LECTURA = 1.0       # segundos de espera antes de leer el receptor


      def saltar_a(i):
          # Apaga los tonos, pasa a la portadora numero i y los vuelve a encender.
          # Asi no sale ningun tono mientras la placa cambia de frecuencia.
          self.set_silencio(1)
          time.sleep(ESPERA_SILENCIO)
          self.set_indice(i)
          self.set_silencio(0)


      def medir_todas_las_lineas():
          # Recorre las portadoras y anota el nivel de cada linea leido por el RX.
          # A cada lectura le resta lo que el propio RX lee de mas en esa linea.
          respuesta = self.get_respuesta_rx()
          niveles = []
          for i in range(self.get_n_port()):
              saltar_a(i)
              time.sleep(ESPERA_LECTURA)
              niveles.append(self.get_nivel_inf() - respuesta[2 * i])
              niveles.append(self.get_nivel_sup() - respuesta[2 * i + 1])
          return niveles


      def calibrar():
          cantidad = 2 * self.get_n_port()             # cantidad de lineas
          correcciones = [0.0] * cantidad              # se empieza sin corregir nada
          self.set_correcciones(correcciones)

          self.set_etapa('CALIBRACION, vuelta 1 de 3: midiendo sin corregir')
          niveles = medir_todas_las_lineas()
          if min(niveles) < -75 or max(niveles) > -10:
              self.set_resultado('CANCELADA: niveles fuera de rango (revisar el cable y las ganancias)')
              return
          objetivo = min(niveles)                      # todas las lineas bajan hasta la mas debil
          planitud_antes = max(niveles) - min(niveles)
          self.set_desvio_antes([n - objetivo for n in niveles])

          for vuelta in [2, 3]:
              nuevas = []
              for k in range(cantidad):
                  c = correcciones[k] + (objetivo - niveles[k])
                  if c > 0:
                      c = 0.0                          # una linea no puede subir mas que el maximo
                  nuevas.append(c)
              correcciones = nuevas
              self.set_correcciones(correcciones)
              self.set_etapa('CALIBRACION, vuelta %d de 3: midiendo con la correccion' % vuelta)
              niveles = medir_todas_las_lineas()

          self.set_desvio_despues([n - objetivo for n in niveles])
          planitud_despues = max(niveles) - min(niveles)
          self.set_resultado('antes %.1f dB, despues %.1f dB' % (planitud_antes, planitud_despues))


      def transmitir_una_pasada():
          for i in range(self.get_n_port()):
              if self.get_orden() != 2:
                  return                               # cambio la orden: se corta la pasada
              saltar_a(i)
              time.sleep(self.get_permanencia())
          self.set_pasadas(self.get_pasadas() + 1)


      def receta():
          time.sleep(2)                                # deja que el flujo termine de arrancar
          while True:
              if self.get_orden() == 1:
                  calibrar()
                  self.set_orden(0)                    # al terminar vuelve a esperar
              elif self.get_orden() == 2:
                  self.set_etapa('TRANSMISION')
                  transmitir_una_pasada()
              else:
                  self.set_etapa('EN ESPERA (sin emitir)')
                  self.set_silencio(1)
                  time.sleep(0.2)


      threading.Thread(target=receta, daemon=True).start()
  states: {}

connections:
- [tono_superior, '0', suma, '0']
- [tono_inferior, '0', suma, '1']
- [suma, '0', osmosdr_sink_0, '0']
- [filtro_sup, '0', potencia_sup, '0']
- [potencia_sup, '0', promedio_sup, '0']
- [promedio_sup, '0', a_db_sup, '0']
- [a_db_sup, '0', sonda_sup, '0']
- [osmosdr_source_0, '0', filtro_sup, '0']
- [filtro_inf, '0', potencia_inf, '0']
- [potencia_inf, '0', promedio_inf, '0']
- [promedio_inf, '0', a_db_inf, '0']
- [a_db_inf, '0', sonda_inf, '0']
- [osmosdr_source_0, '0', filtro_inf, '0']
- [datos_curva_antes, '0', ritmo_grafico_medicion, '0']
- [ritmo_grafico_medicion, '0', grafico_medicion, '0']
- [datos_curva_despues, '0', grafico_medicion, '1']
- [datos_curva_correccion, '0', ritmo_grafico_correccion, '0']
- [ritmo_grafico_correccion, '0', grafico_correccion, '0']
- [datos_curva_actual, '0', grafico_correccion, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
