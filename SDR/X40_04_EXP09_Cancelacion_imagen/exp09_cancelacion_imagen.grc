options:
  parameters:
    description: EXP-09 cancelacion de la imagen sumando c*conj(x) - bladeRF x40 contra tinySA por cable
    generate_options: qt_gui
    id: exp09_cancelacion_imagen
    output_language: python
    title: EXP-09 cancelacion de imagen por pre-correccion IQ
  states: {}

blocks:
- name: amp
  id: variable_qtgui_chooser
  parameters:
    label: Amplitud digital
    labels: '[''0.1'', ''0.2'', ''0.3'', ''0.4'', ''0.5'', ''0.6'', ''0.7'']'
    num_opts: '0'
    options: '[0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7]'
    type: raw
    value: '0.5'
  states: {}
- name: c
  id: variable
  parameters:
    comment: Coeficiente de pre-correccion IQ
    value: corr_on * 10**(k_db/20) * np.exp(1j*np.deg2rad(phi_deg))
  states: {}
- name: corr_on
  id: variable_qtgui_chooser
  parameters:
    label: Correccion
    label0: Apagada
    label1: Encendida
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: f_fuga
  id: variable_qtgui_label
  parameters:
    label: Fuga de portadora (MHz)
    type: real
    value: freq / 1e6
  states: {}
- name: f_imagen
  id: variable_qtgui_label
  parameters:
    label: Imagen (MHz)
    type: real
    value: (freq - tone_freq) / 1e6
  states: {}
- name: f_start
  id: variable_qtgui_label
  parameters:
    label: tinySA START (MHz)
    type: real
    value: (freq - 1.2e6) / 1e6
  states: {}
- name: f_stop
  id: variable_qtgui_label
  parameters:
    label: tinySA STOP (MHz)
    type: real
    value: (freq + 0.8e6) / 1e6
  states: {}
- name: f_tono
  id: variable_qtgui_label
  parameters:
    label: Tono util (MHz)
    type: real
    value: (freq + tone_freq) / 1e6
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Portadora
    label0: 400 MHz
    label1: 600 MHz
    num_opts: '2'
    option0: 400e6
    option1: 600e6
    orient: Qt.QHBoxLayout
    type: real
    value: 400e6
    widget: radio_buttons
  states: {}
- name: k_db
  id: variable_qtgui_range
  parameters:
    label: Nivel de la correccion |c| (dB respecto del tono)
    min_len: '400'
    start: '-50'
    step: '0.1'
    stop: '-20'
    value: '-34'
  states: {}
- name: phi_deg
  id: variable_qtgui_range
  parameters:
    label: Fase de la correccion (grados)
    min_len: '400'
    start: '-180'
    step: '0.5'
    stop: '180'
    value: '0'
  states: {}
- name: pico_bb
  id: variable_qtgui_label
  parameters:
    label: Pico de banda base (debe ser < 1)
    type: real
    value: amp * (1 + corr_on * 10**(k_db/20))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tone_freq
  id: variable_qtgui_chooser
  parameters:
    label: Tono de banda base
    label0: 200 kHz
    label1: 600 kHz
    num_opts: '2'
    option0: 200e3
    option1: 600e3
    orient: Qt.QHBoxLayout
    type: real
    value: 200e3
    widget: radio_buttons
  states: {}
- name: tx_gain
  id: variable_qtgui_chooser
  parameters:
    label: Ganancia TX (dB)
    label0: '17'
    label1: '20'
    label2: '25'
    label3: '30'
    num_opts: '4'
    option0: '17'
    option1: '20'
    option2: '25'
    option3: '30'
    orient: Qt.QHBoxLayout
    type: real
    value: '17'
    widget: radio_buttons
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: c
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=0
    bb_gain0: '0'
    freq0: freq
    gain0: tx_gain
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
