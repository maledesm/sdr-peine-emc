options:
  parameters:
    description: 'bladeRF 2.0 micro xA9: 24 lineas cada 40 MHz, un tono por portadora, con la portadora 10 MHz por encima de la linea y 40 MSPS. Con las lineas desde 60 MHz, los armonicos del oscilador y la imagen del muestreo caen sobre otras lineas del peine; desde 50 MHz caen en el medio. Calibracion desde la captura del analizador, siempre a 0 dBm, con opcion de subir todo 3 dB. SOLO para medir con el analizador: nunca con el cable en RX1'
    generate_options: qt_gui
    id: exp26_a9_peine_radiado_desde60
    output_language: python
    title: 'EXP-26 xA9: peine de 60 a 980 MHz para ensayo radiado'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Tasa de muestreo. Con 40 MSPS la imagen del
      muestreo cae 40 MHz arriba de la linea, o
      sea sobre la linea siguiente
    value: 40e6
  states: {}
- name: f_tono
  id: variable
  parameters:
    comment: |-
      El tono va por debajo de la portadora: asi
      la linea de 50 MHz no obliga a sintonizar
      por debajo de 47 MHz
    value: '-separacion * 1e6'
  states: {}
- name: ancho_banda
  id: variable
  parameters:
    comment: Filtro analogico de la placa
    value: 0.9 * samp_rate
  states: {}
- name: ganancia_de_lectura
  id: variable
  parameters:
    comment: |-
      Ganancia de TX a la que estan referidos los
      valores de los contadores y del archivo de
      calibracion
    value: '45'
  states: {}
- name: amp_base
  id: variable
  parameters:
    comment: |-
      Amplitud del tono sin compensar: deja las
      lineas unos 3 dB por debajo de 0 dBm
    value: '0.25'
  states: {}
- name: amp_max
  id: variable
  parameters:
    comment: Amplitud maxima del tono. No debe llegar a 1
    value: '0.95'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: f_primera
  id: variable
  parameters:
    comment: Primera linea del peine
    value: 60e6
  states: {}
- name: paso_lineas
  id: variable
  parameters:
    comment: Separacion entre lineas
    value: 40e6
  states: {}
- name: n_lineas
  id: variable
  parameters:
    comment: 'Cantidad de lineas: 24, de 60 a 980 MHz'
    value: '24'
  states: {}
- name: permanencia
  id: variable
  parameters:
    comment: |-
      Segundos con el tono encendido en cada
      linea, y otros tantos apagado. Mas de dos
      barridos del analizador (2,8 s en la tinySA
      para toda la banda)
    value: '6.0'
  states: {}
- name: archivo
  id: variable
  parameters:
    comment: |-
      Archivo donde se guarda la calibracion, en
      la carpeta del flujo
    value: '''calibracion_peine_desde60.txt'''
  states: {}
- name: estado_archivo
  id: variable
  parameters:
    comment: |-
      Texto sobre el archivo de calibracion. Lo
      cambian los botones
    value: '''hay una guardada, sin importar'' if os.path.exists(archivo) else ''todavia no hay ninguna guardada'''
  states: {}
- name: muestras_por_bloque
  id: variable
  parameters:
    comment: |-
      Muestras en cada envio por USB. Con bloques
      grandes anduvieron los 40 MSPS en el EXP-22;
      con 4096 titilaba el LED a 30 MSPS
    value: '16384'
  states: {}
- name: bloques_usb
  id: variable
  parameters:
    comment: |-
      Bloques en espera. Con 128 x 16384 la
      amplitud tarda 0,05 s en llegar a la salida
    value: '128'
  states: {}
- name: lista_de_pasos
  id: variable
  parameters:
    comment: 'Los pasos del barrido: 0, 1, 2, ...'
    value: list(range(100000))
  states: {}
- name: paso
  id: variable_function_probe
  parameters:
    block_id: lista_de_pasos
    comment: |-
      Cada media 'permanencia' saca el primer
      numero de la lista. Cada linea ocupa 4 de
      estos pasos
    function_args: '0'
    function_name: pop
    poll_rate: 2.0 / permanencia
    value: '-1'
  states: {}
- name: fase
  id: variable
  parameters:
    comment: |-
      Con silencio: 0 y 1 encendido, 2 apagado, 3
      apagado y ya en la frecuencia siguiente. Sin
      silencio: siempre encendido
    value: max(paso, 0) % (4 if silencio == 1 else 2)
  states: {}
- name: ciclo
  id: variable
  parameters:
    comment: |-
      Numero de linea desde el arranque. Con
      silencio cada linea ocupa 4 pasos; sin
      silencio, 2
    value: ((max(paso, 0) + 1) // 4) if silencio == 1 else (max(paso, 0) // 2)
  states: {}
- name: pasos_por_pasada
  id: variable
  parameters:
    comment: |-
      Recorriendo por nivel se agrega un paso en
      silencio al final de cada pasada
    value: n_lineas + 1 if orden_recorrido == 1 else n_lineas
  states: {}
- name: posicion
  id: variable
  parameters:
    comment: Lugar dentro de la pasada, desde 0
    value: ciclo % pasos_por_pasada
  states: {}
- name: pasada
  id: variable
  parameters:
    comment: Cuantas veces se recorrio el peine
    value: ciclo // pasos_por_pasada + 1
  states: {}
- name: orden
  id: variable
  parameters:
    comment: |-
      En que orden se visitan las lineas: por
      frecuencia, o de la menos compensada a la
      mas compensada
    value: 'sorted(range(n_lineas), key=lambda p: comp[p]) if orden_recorrido == 1 else list(range(n_lineas))'
  states: {}
- name: indice
  id: variable
  parameters:
    comment: |-
      Linea actual, de 0 a n_lineas - 1. El valor
      n_lineas es el paso en silencio del final de
      la pasada
    value: fijo if fijo >= 0 else (orden[posicion] if posicion < n_lineas else n_lineas)
  states: {}
- name: entre_pasadas
  id: variable
  parameters:
    comment: 1 durante el paso en silencio
    value: 1 if indice >= n_lineas else 0
  states: {}
- name: indice_freq
  id: variable
  parameters:
    comment: |-
      Durante el paso en silencio la placa se
      queda en la ultima linea
    value: orden[n_lineas - 1] if indice >= n_lineas else indice
  states: {}
- name: linea
  id: variable
  parameters:
    comment: Frecuencia de la linea actual
    value: f_primera + paso_lineas * indice_freq
  states: {}
- name: freq
  id: variable
  parameters:
    comment: |-
      Frecuencia de la portadora: 'separacion' MHz
      por encima de la linea
    value: linea - f_tono
  states: {}
- name: pausa
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 1,0,1,4
    label: 'PAUSA: la salida queda en silencio. Destildar para transmitir'
    type: int
    'true': '1'
    'false': '0'
    value: '1'
  states: {}
- name: orden_recorrido
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,9,1,3
    label: Orden
    labels: '[''Por frecuencia'', ''De menor a mayor nivel'']'
    options: '[0, 1]'
    num_opts: '0'
    type: int
    value: '0'
  states: {}
- name: ganancia
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Tres puntos, de a 10 dB. La compensacion es
      la misma en los tres
    gui_hint: 2,0,1,3
    label: Ganancia de TX
    labels: '[''45 dB: lineas en -20 dBm'', ''55 dB: lineas en -10 dBm'', ''65 dB: lineas en 0 dBm'']'
    options: '[45, 55, 65]'
    num_opts: '0'
    type: int
    value: '45'
  states: {}
- name: subida
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      La calibracion es siempre a 0 dBm (con
      ganancia 65). Esto le suma 3 dB a todas las
      lineas que ya tienen valor cargado
    gui_hint: 2,3,1,3
    label: Nivel
    labels: '[''Calibrado'', ''Calibrado + 3 dB'']'
    options: '[0, 3]'
    num_opts: '0'
    type: int
    value: '0'
  states: {}
- name: separacion
  id: variable
  parameters:
    comment: |-
      MHz entre la linea y la portadora. Con
      lineas cada 40 MHz tiene que ser 10: asi los
      armonicos caen a multiplos de 40 MHz de la
      linea
    value: '10'
  states: {}
- name: boton_generar
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 5,0,1,4
    label: Generar calibracion (desde la captura .csv)
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: boton_guardar
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 5,4,1,4
    label: Guardar calibracion
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: boton_importar
  id: variable_qtgui_push_button
  parameters:
    comment: |-
      Vale 1 mientras esta apretado. La accion
      esta en el Python Snippet
    gui_hint: 5,8,1,4
    label: Importar calibracion previa
    type: int
    value: '0'
    pressed: '1'
    released: '0'
  states: {}
- name: medidos
  id: variable
  parameters:
    comment: |-
      Valor leido en el analizador para cada
      linea, en dBm. 0 significa sin dato
    value: '[m_60, m_100, m_140, m_180, m_220, m_260, m_300, m_340, m_380, m_420, m_460, m_500, m_540, m_580, m_620, m_660, m_700, m_740, m_780, m_820, m_860, m_900, m_940, m_980]'
  states: {}
- name: comp
  id: variable
  parameters:
    comment: |-
      Compensacion de cada linea, en dB: lo que le
      falta para 0 dBm con ganancia 65. Sin dato,
      no compensa
    value: '[(0.0 if leido == 0 else (ganancia_de_lectura - 65) - leido) for leido in medidos]'
  states: {}
- name: pedido
  id: variable
  parameters:
    comment: |-
      Compensacion mas los 3 dB de subida, si
      estan elegidos. Las lineas sin dato quedan
      como estan
    value: '[(0.0 if leido == 0 else comp[k] + subida) for k, leido in enumerate(medidos)]'
  states: {}
- name: amp_tabla
  id: variable
  parameters:
    comment: |-
      Amplitud del tono para cada linea, con tope
      en amp_max. El cero del final es el paso en
      silencio
    value: '[min(amp_base * 10 ** (db / 20.0), amp_max) for db in pedido] + [0.0]'
  states: {}
- name: sin_margen
  id: variable
  parameters:
    comment: Lineas que piden mas amplitud de la que hay
    value: sum(1 for db in pedido if amp_base * 10 ** (db / 20.0) > amp_max)
  states: {}
- name: cargadas
  id: variable
  parameters:
    comment: Lineas que ya tienen un valor cargado
    value: sum(1 for leido in medidos if leido != 0)
  states: {}
- name: emite
  id: variable
  parameters:
    comment: 1 cuando el tono esta encendido
    value: 1 if (pausa == 0 and paso >= 0 and (fase < 2 or fijo >= 0 or silencio == 0 or congelar == 1)) else 0
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: |-
      Ganancia que recibe la placa: en pausa baja
      al minimo
    value: ganancia if pausa == 0 else 0
  states: {}
- name: amp_tx
  id: variable
  parameters:
    comment: Amplitud del tono de esta linea
    value: amp_tabla[indice] if emite == 1 else 0
  states: {}
- name: nivel_sin_calibrar
  id: variable
  parameters:
    comment: |-
      Nivel aproximado de una linea sin calibrar,
      en dBm, segun la ganancia elegida
    value: ganancia - 68
  states: {}
- name: etapa
  id: variable
  parameters:
    comment: Texto de la etapa actual
    value: '''PAUSA (sin emitir)'' if pausa == 1 else (''INICIACION'' if paso < 0 else (''LINEA FIJA, emision continua'' if fijo >= 0 else (''LINEA CONGELADA, emision continua'' if congelar == 1 else (''SILENCIO (salto de frecuencia), pasada %d'' % pasada if (entre_pasadas == 1 or (fase >= 2 and silencio == 1)) else ''TRANSMISION, pasada %d'' % pasada))))'
  states: {}
- name: et_etapa
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:15pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,0,1,4
    label: '<span style=''font-size:15pt''>Etapa: </span>'
    type: string
    value: etapa
  states: {}
- name: et_linea
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:15pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,4,1,4
    label: '<span style=''font-size:15pt''>Linea: </span>'
    type: string
    value: ('%.0f MHz (fija)' % (linea / 1e6)) if fijo >= 0 else '%.0f MHz (paso %d de %d)' % (linea / 1e6, posicion + 1, pasos_por_pasada)
  states: {}
- name: et_portadora
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:15pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 0,8,1,4
    label: '<span style=''font-size:15pt''>Portadora: </span>'
    type: string
    value: '''%.0f MHz'' % (freq / 1e6)'
  states: {}
- name: et_tiempos
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 4,8,1,4
    label: '<span style=''font-size:11pt''>Pasada completa: </span>'
    type: string
    value: ('%d min %02d s (%.0f s encendido y %.0f s apagado por linea)' % (2 * permanencia * pasos_por_pasada // 60, 2 * permanencia * pasos_por_pasada % 60, permanencia, permanencia)) if silencio == 1 else ('%d min %02d s (%.0f s por linea, sin silencio)' % (permanencia * pasos_por_pasada // 60, permanencia * pasos_por_pasada % 60, permanencia))
  states: {}
- name: et_comp
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 3,4,1,4
    label: '<span style=''font-size:11pt''>Amplitud de esta linea: </span>'
    type: string
    value: '''%.3f (%+.1f dB sobre la base)'' % (amp_tabla[indice_freq], pedido[indice_freq])'
  states: {}
- name: et_cargadas
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 4,0,1,4
    label: '<span style=''font-size:11pt''>Lineas con valor cargado: </span>'
    type: string
    value: '''%d de %d'' % (cargadas, n_lineas)'
  states: {}
- name: et_margen
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 4,4,1,4
    label: '<span style=''font-size:11pt''>Lineas que piden mas de lo que hay: </span>'
    type: int
    value: sin_margen
  states: {}
- name: et_espurias
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 3,8,1,4
    label: '<span style=''font-size:11pt''>De esta linea: </span>'
    type: string
    value: '''fuga en %.0f MHz, imagen en %.0f MHz'' % (freq / 1e6, (freq - f_tono) / 1e6)'
  states: {}
- name: et_archivo
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 6,0,1,12
    label: '<span style=''font-size:11pt''>Calibracion en archivo: </span>'
    type: string
    value: estado_archivo
  states: {}
- name: et_titulo
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''>" + str(x) + "</span>"'
    gui_hint: 8,0,1,12
    label: '<span style=''font-size:11pt''><b>Valor de cada linea (MHz) sin calibrar, en dBm: </b></span>'
    type: string
    value: '''referido a la ganancia de %d dB (lo leido menos %d dB con el selector en 65). Lo carga Generar calibracion'' % (ganancia_de_lectura, 65 - ganancia_de_lectura)'
  states: {}
- name: et_nivel
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 3,0,1,4
    label: '<span style=''font-size:11pt''>Con esta ganancia: </span>'
    type: string
    value: '''sin calibrar unos %d dBm, calibradas %d dBm'' % (nivel_sin_calibrar, ganancia - 65 + subida)'
  states: {}
- name: et_tasa
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "<span style=''font-size:11pt''><b>" + str(x) + "</b></span>"'
    gui_hint: 7,0,1,12
    label: '<span style=''font-size:11pt''>Tasa de muestreo: </span>'
    type: string
    value: '''%.0f MSPS, filtro de %.1f MHz'' % (samp_rate / 1e6, ancho_banda / 1e6)'
  states: {}
- name: tono
  id: analog_sig_source_x
  parameters:
    comment: |-
      Un solo tono, 'separacion' MHz por debajo de
      la portadora
    amp: amp_tx
    freq: f_tono
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"bladerf=321e0fa5875945d99b11070bb0a76d31,buffers=" + str(bloques_usb) + ",buflen=" + str(muestras_por_bloque)'
    bb_gain0: '0'
    bw0: ancho_banda
    comment: |-
      bladeRF 2.0 micro xA9, salida TX1. Solo
      hacia el analizador
    freq0: freq
    gain0: tx_gain
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: linea_de_punto
  id: variable
  parameters:
    comment: |-
      El grafico tiene 512 puntos repartidos entre
      las lineas
    value: '[j * n_lineas // 512 for j in range(512)]'
  states: {}
- name: curva_comp
  id: variable
  parameters:
    comment: Lo pedido a cada linea, punto por punto
    value: '[pedido[k] for k in linea_de_punto]'
  states: {}
- name: curva_actual
  id: variable
  parameters:
    comment: Marca la linea que sale ahora
    value: '[(pedido[k] if (k == indice and emite == 1) else -2) for k in linea_de_punto]'
  states: {}
- name: datos_comp
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: curva_comp
    vlen: '512'
  states: {}
- name: datos_actual
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: curva_actual
    vlen: '512'
  states: {}
- name: ritmo_grafico
  id: blocks_throttle2
  parameters:
    comment: Solo marca el ritmo del grafico
    limit: time
    maximum: '0.01'
    samples_per_second: '2000'
    type: float
    vlen: '512'
  states: {}
- name: grafico
  id: qtgui_vector_sink_f
  parameters:
    name: '"Lo que se le suma a cada linea"'
    vlen: '512'
    x_start: (f_primera - paso_lineas / 2) / 1e6
    x_step: n_lineas * paso_lineas / 1e6 / 512
    x_axis_label: '"Frecuencia de la linea"'
    y_axis_label: '"Sobre la base"'
    x_units: '"MHz"'
    y_units: '"dB"'
    grid: 'True'
    ymin: '-2'
    ymax: '12'
    nconnections: '2'
    gui_hint: 11,0,1,12
    label1: '"Pedido a cada linea"'
    width1: '2'
    label2: '"Linea que sale ahora"'
    width2: '3'
  states: {}
- name: m_60
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,0,1,1
    label: <div align='right'>60:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_100
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,1,1,1
    label: <div align='right'>100:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_140
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,2,1,1
    label: <div align='right'>140:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_180
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,3,1,1
    label: <div align='right'>180:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_220
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,4,1,1
    label: <div align='right'>220:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_260
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,5,1,1
    label: <div align='right'>260:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_300
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,6,1,1
    label: <div align='right'>300:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_340
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,7,1,1
    label: <div align='right'>340:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_380
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,8,1,1
    label: <div align='right'>380:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_420
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,9,1,1
    label: <div align='right'>420:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_460
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,10,1,1
    label: <div align='right'>460:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_500
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,11,1,1
    label: <div align='right'>500:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_540
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,0,1,1
    label: <div align='right'>540:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_580
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,1,1,1
    label: <div align='right'>580:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_620
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,2,1,1
    label: <div align='right'>620:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_660
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,3,1,1
    label: <div align='right'>660:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_700
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,4,1,1
    label: <div align='right'>700:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_740
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,5,1,1
    label: <div align='right'>740:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_780
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,6,1,1
    label: <div align='right'>780:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_820
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,7,1,1
    label: <div align='right'>820:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_860
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,8,1,1
    label: <div align='right'>860:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_900
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,9,1,1
    label: <div align='right'>900:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_940
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,10,1,1
    label: <div align='right'>940:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: m_980
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,11,1,1
    label: <div align='right'>980:&nbsp;</div>
    min_len: '50'
    start: '-40'
    step: '0.1'
    stop: '3'
    value: '0'
    widget: counter
  states: {}
- name: archivos_de_calibracion
  id: snippet
  parameters:
    comment: |-
      Genera la calibracion desde una captura, la
      guarda en un archivo y la vuelve a cargar
    section: main_after_init
    code: |
      # ============================================================================
      # ARCHIVOS DE CALIBRACION
      # Es el unico codigo Python del flujo. Hace falta porque los bloques no saben
      # escribir ni leer archivos.
      #   Boton "Generar calibracion": pide la captura (.csv) que guardo el analizador
      #   con el peine SIN calibrar, busca el pico de cada linea, lo carga en su
      #   contador y guarda el archivo de calibracion.
      #   Boton "Guardar calibracion": escribe en un archivo de texto los 24 valores
      #   cargados en la ventana, uno por renglon, junto a su frecuencia.
      #   Boton "Importar calibracion previa": lee ese archivo y pone cada valor en
      #   su contador.
      # ============================================================================
      import os
      import time

      PRIMERA_LINEA = 60        # MHz
      SEPARACION = 40           # MHz entre una linea y la siguiente
      CERCA = 4                 # MHz: hasta que distancia de una linea se busca su pico

      # Los 24 contadores de la ventana, en orden de frecuencia (60, 100, ... 980 MHz).
      # d_widget es la casilla con flechas que se ve en pantalla.
      contadores = [
          self._m_60_win.d_widget, self._m_100_win.d_widget, self._m_140_win.d_widget,
          self._m_180_win.d_widget, self._m_220_win.d_widget, self._m_260_win.d_widget,
          self._m_300_win.d_widget, self._m_340_win.d_widget, self._m_380_win.d_widget,
          self._m_420_win.d_widget, self._m_460_win.d_widget, self._m_500_win.d_widget,
          self._m_540_win.d_widget, self._m_580_win.d_widget, self._m_620_win.d_widget,
          self._m_660_win.d_widget, self._m_700_win.d_widget, self._m_740_win.d_widget,
          self._m_780_win.d_widget, self._m_820_win.d_widget, self._m_860_win.d_widget,
          self._m_900_win.d_widget, self._m_940_win.d_widget, self._m_980_win.d_widget,
      ]


      def guardar():
          valores = self.get_medidos()                 # los 24 valores de la ventana
          try:
              archivo = open(self.get_archivo(), 'w')
              # primer renglon: cuando se guardo y con que ganancia se leyeron los valores
              archivo.write('# guardada el ' + time.strftime('%d-%m-%Y %H:%M') +
                            ', valores leidos con ganancia %d dB\n' % self.get_ganancia_de_lectura())
              for k in range(len(valores)):
                  frecuencia = PRIMERA_LINEA + SEPARACION * k
                  archivo.write('%d %.1f\n' % (frecuencia, valores[k]))
              archivo.close()
          except Exception:
              self.set_estado_archivo('NO se pudo guardar')
              return False
          self.set_estado_archivo('guardada a las ' + time.strftime('%H:%M:%S'))
          return True


      def importar():
          if not os.path.exists(self.get_archivo()):
              self.set_estado_archivo('no hay ninguna calibracion guardada')
              return
          try:
              archivo = open(self.get_archivo())
              renglones = archivo.readlines()
              archivo.close()
              if renglones[0].startswith('#'):
                  renglones = renglones[1:]            # se saltea el renglon de encabezado
              valores = []
              for k in range(len(contadores)):
                  partes = renglones[k].split()        # cada renglon: frecuencia y valor
                  valores.append(float(partes[1]))
          except Exception:
              self.set_estado_archivo('el archivo no se pudo leer: no se importo nada')
              return
          for k in range(len(contadores)):
              contadores[k].setValue(valores[k])       # al cambiar el contador, el flujo se actualiza solo
          self.set_estado_archivo('importada a las ' + time.strftime('%H:%M:%S'))


      def leer_captura(nombre):
          # Lee una captura del analizador: un renglon por punto, con la frecuencia y
          # el nivel separados por una coma. Devuelve dos listas: MHz y dBm.
          frecuencias = []
          niveles = []
          archivo = open(nombre)
          for renglon in archivo:
              partes = renglon.replace(';', ',').split(',')
              try:
                  frecuencia = float(partes[0])
                  nivel = float(partes[1])
              except Exception:
                  continue                             # renglon de titulo o vacio: se saltea
              if frecuencia > 100000:
                  frecuencia = frecuencia / 1e6        # estaba en Hz: se pasa a MHz
              frecuencias.append(frecuencia)
              niveles.append(nivel)
          archivo.close()
          return frecuencias, niveles


      def pico_de_la_linea(frecuencias, niveles, linea):
          # Devuelve el nivel mas alto que hay en la captura a menos de 4 MHz de la
          # linea. El pico casi nunca cae justo en la frecuencia de la linea, por eso
          # se busca cerca. Las lineas vecinas estan a 40 MHz: quedan afuera.
          # Si la captura no llega hasta esa frecuencia, devuelve None.
          if linea < min(frecuencias) or linea > max(frecuencias):
              return None
          pico = None
          for j in range(len(frecuencias)):
              if abs(frecuencias[j] - linea) <= CERCA:
                  if pico is None or niveles[j] > pico:
                      pico = niveles[j]
          return pico


      def generar():
          # La captura tiene que ser del peine sin calibrar: con los contadores en 0
          if self.get_cargadas() > 0:
              self.set_estado_archivo('NO se genero: ya hay valores cargados. Cerrar el programa, '
                                      'abrirlo de nuevo y capturar el peine sin calibrar')
              return

          # 1) Elegir la captura. Se pueden elegir varias a la vez
          elegido = Qt.QFileDialog.getOpenFileNames(self, 'Elegir la captura del peine SIN calibrar', '',
                                                    'Capturas del analizador (*.csv)')
          nombres = elegido[0]
          if len(nombres) == 0:
              return                                   # se cerro la ventana sin elegir nada

          # 2) Leer cada captura
          capturas = []
          for nombre in nombres:
              try:
                  frecuencias, niveles = leer_captura(nombre)
              except Exception:
                  frecuencias = []
              if len(frecuencias) == 0:
                  self.set_estado_archivo('NO se genero: no se pudo leer ' + os.path.basename(nombre))
                  return
              capturas.append([frecuencias, niveles])

          # 3) Buscar el pico de cada linea
          ganancia = self.get_ganancia()               # ganancia de TX elegida en la ventana
          esperado = self.get_nivel_sin_calibrar()     # nivel aproximado de una linea sin calibrar
          valores = []                                 # un valor por linea; None si no hay dato
          for k in range(len(contadores)):
              linea = PRIMERA_LINEA + SEPARACION * k
              leidos = []
              for captura in capturas:
                  pico = pico_de_la_linea(captura[0], captura[1], linea)
                  if pico is not None:
                      leidos.append(pico)
              if len(leidos) == 0:
                  valores.append(None)                 # ninguna captura llega hasta esta linea
                  continue
              # Con varias capturas se usa el valor mas bajo: MAX HOLD a veces retiene
              # un pico momentaneo, y es raro que caiga dos veces en la misma linea
              valor = min(leidos)
              # Control: si el valor esta lejos de lo esperado, la captura no sirve
              if valor > esperado + 6 or valor < esperado - 8:
                  self.set_estado_archivo('NO se genero: en %d MHz se leyo %.1f dBm y con ganancia %d dB '
                                          'se esperaba cerca de %d dBm' % (linea, valor, ganancia, esperado))
                  return
              valores.append(valor)

          # 4) Cargar los contadores. El flujo espera valores leidos con la ganancia
          #    de lectura (45 dB): se resta lo que haya de mas en la ganancia usada
          diferencia = ganancia - self.get_ganancia_de_lectura()
          cuantas = 0
          for k in range(len(contadores)):
              if valores[k] is not None:
                  contadores[k].setValue(round(valores[k] - diferencia, 1))
                  cuantas = cuantas + 1
          if cuantas == 0:
              self.set_estado_archivo('NO se genero: la captura no llega a ninguna linea del peine')
              return

          # 5) Guardar el archivo de calibracion
          if guardar():
              self.set_estado_archivo('generada a las %s con %d captura(s): %d lineas, leidas con ganancia %d dB'
                                      % (time.strftime('%H:%M:%S'), len(capturas), cuantas, ganancia))


      # GNU Radio llama a set_boton_guardar(1) cuando se aprieta el boton y a
      # set_boton_guardar(0) cuando se suelta. Aca se define que hace esa llamada.
      def al_tocar_guardar(valor):
          if valor == 1:
              guardar()


      def al_tocar_importar(valor):
          if valor == 1:
              importar()


      # Este se hace al soltar el boton: si se hiciera al apretarlo, el boton quedaria
      # hundido mientras esta abierta la ventana para elegir el archivo.
      def al_tocar_generar(valor):
          if valor == 0:
              generar()


      self.set_boton_guardar = al_tocar_guardar
      self.set_boton_importar = al_tocar_importar
      self.set_boton_generar = al_tocar_generar


      # ============================================================================
      # NO RESINTONIZAR DE MAS
      # El paso del barrido cambia 4 veces por linea (encendido, encendido, apagado,
      # apagado) y GNU Radio vuelve a mandar la frecuencia a la placa en cada cambio,
      # aunque sea la misma. La placa resintoniza igual, y eso con el tono encendido
      # lo perturba. Aca se hace que la frecuencia se mande solo cuando cambia.
      # ============================================================================
      mandar_frecuencia = self.set_freq


      def mandar_frecuencia_si_cambia(frecuencia):
          if frecuencia != self.get_freq():
              mandar_frecuencia(frecuencia)


      self.set_freq = mandar_frecuencia_si_cambia



      # ============================================================================
      # CONGELAR EL BARRIDO
      # Mientras la casilla CONGELAR esta tildada, el paso del barrido no avanza: la
      # placa se queda en la linea que estaba saliendo. (El flujo, por su lado, deja
      # el tono encendido mientras este congelado.)
      # ============================================================================
      avanzar_paso = self.set_paso


      def avanzar_paso_si_no_esta_congelado(valor):
          if self.get_congelar() == 0:
              avanzar_paso(valor)
          else:
              # se devuelve el numero a la lista: al destildar, el barrido sigue donde estaba
              self.get_lista_de_pasos().insert(0, valor)


      self.set_paso = avanzar_paso_si_no_esta_congelado
  states: {}
- name: fijo
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Barrido completo, o una sola linea emitida
      en forma continua (para orientar las antenas
      o mirar una linea de cerca)
    gui_hint: 2,6,1,3
    label: Modo
    labels: '[''Barrido completo''] + [''Fija en %d MHz'' % (60 + 40 * k) for k in range(24)]'
    options: '[-1] + list(range(24))'
    num_opts: '0'
    type: int
    value: '-1'
  states: {}
- name: congelar
  id: variable_qtgui_check_box
  parameters:
    comment: |-
      Detiene el barrido en la linea que esta
      saliendo y la deja emitiendo en forma
      continua. Al destildar, el barrido sigue
      desde ahi
    gui_hint: 1,4,1,4
    label: CONGELAR en la linea actual (sigue emitiendo)
    type: int
    'true': '1'
    'false': '0'
    value: '0'
  states: {}
- name: silencio
  id: variable_qtgui_check_box
  parameters:
    comment: |-
      Tildada: cada linea esta 6 s encendida y 6 s
      apagada, y el salto se hace en silencio.
      Destildada: 6 s por linea, siempre encendida
      (como el EXP-24)
    gui_hint: 1,8,1,4
    label: Silencio en cada salto
    type: int
    'true': '1'
    'false': '0'
    value: '1'
  states: {}

connections:
- [tono, '0', osmosdr_sink_0, '0']
- [datos_comp, '0', ritmo_grafico, '0']
- [ritmo_grafico, '0', grafico, '0']
- [datos_actual, '0', grafico, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
