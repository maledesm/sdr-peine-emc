options:
  parameters:
    description: 'bladeRF 2.0 micro xA9 a 50 MSPS: cuatro tonos en +/-10 y +/-20 MHz, cada uno con habilitacion, amplitud y fase propias. Para superponer un tono a la imagen de otro'
    generate_options: qt_gui
    id: exp16_a9_cuatro_tonos
    output_language: python
    title: 'EXP-16 xA9: cuatro tonos en banda ancha'
  states: {}

blocks:
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 'Tasa de muestreo: hace falta para llegar a +/-20 MHz. Requiere USB 3'
    value: 50e6
  states: {}
- name: ancho_banda
  id: variable
  parameters:
    comment: Filtro analogico de la placa
    value: 50e6
  states: {}
- name: suma_max
  id: variable
  parameters:
    comment: La suma de amplitudes nunca pasa de este valor (evita el desborde)
    value: '0.95'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,4
    label: Portadora
    labels: '[''100 MHz'', ''500 MHz'', ''1 GHz'', ''1,5 GHz'', ''2 GHz'', ''3 GHz'', ''4 GHz'', ''5 GHz'']'
    options: '[100000000, 500000000, 1000000000, 1500000000, 2000000000, 3000000000, 4000000000, 5000000000]'
    num_opts: '0'
    orient: Qt.QHBoxLayout
    type: real
    value: '100000000'
    widget: radio_buttons
  states: {}
- name: tx_gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,4
    label: Ganancia de transmision (dB)
    labels: '[''0 dB'', ''15 dB'', ''30 dB'', ''45 dB'', ''55 dB'', ''60 dB'']'
    options: '[0, 15, 30, 45, 55, 60]'
    num_opts: '0'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: hab_m20
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 4,0,1,1
    label: Habilitar -20 MHz
    type: int
    'true': '1'
    'false': '0'
    value: '0'
  states: {}
- name: amp_m20
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,0,1,1
    label: Amplitud -20 MHz
    labels: '[''0.005'', ''0.01'', ''0.02'', ''0.05'', ''0.1'', ''0.2'', ''0.3'', ''0.4'', ''0.5'', ''0.6'', ''0.7'', ''0.8'', ''0.9'']'
    options: '[0.005, 0.01, 0.02, 0.05, 0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7, 0.8, 0.9]'
    num_opts: '0'
    type: real
    value: '0.5'
    widget: radio_buttons
  states: {}
- name: fase_m20
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,1
    label: Fase
    min_len: '160'
    orient: QtCore.Qt.Vertical
    start: '-180'
    step: '1'
    stop: '180'
    value: '0'
    widget: slider
  states: {}
- name: hab_m10
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 4,1,1,1
    label: Habilitar -10 MHz
    type: int
    'true': '1'
    'false': '0'
    value: '0'
  states: {}
- name: amp_m10
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,1,1,1
    label: Amplitud -10 MHz
    labels: '[''0.005'', ''0.01'', ''0.02'', ''0.05'', ''0.1'', ''0.2'', ''0.3'', ''0.4'', ''0.5'', ''0.6'', ''0.7'', ''0.8'', ''0.9'']'
    options: '[0.005, 0.01, 0.02, 0.05, 0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7, 0.8, 0.9]'
    num_opts: '0'
    type: real
    value: '0.5'
    widget: radio_buttons
  states: {}
- name: fase_m10
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,1,1,1
    label: Fase
    min_len: '160'
    orient: QtCore.Qt.Vertical
    start: '-180'
    step: '1'
    stop: '180'
    value: '0'
    widget: slider
  states: {}
- name: hab_p10
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 4,2,1,1
    label: Habilitar +10 MHz
    type: int
    'true': '1'
    'false': '0'
    value: '1'
  states: {}
- name: amp_p10
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,2,1,1
    label: Amplitud +10 MHz
    labels: '[''0.005'', ''0.01'', ''0.02'', ''0.05'', ''0.1'', ''0.2'', ''0.3'', ''0.4'', ''0.5'', ''0.6'', ''0.7'', ''0.8'', ''0.9'']'
    options: '[0.005, 0.01, 0.02, 0.05, 0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7, 0.8, 0.9]'
    num_opts: '0'
    type: real
    value: '0.5'
    widget: radio_buttons
  states: {}
- name: fase_p10
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,2,1,1
    label: Fase
    min_len: '160'
    orient: QtCore.Qt.Vertical
    start: '-180'
    step: '1'
    stop: '180'
    value: '0'
    widget: slider
  states: {}
- name: hab_p20
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 4,3,1,1
    label: Habilitar +20 MHz
    type: int
    'true': '1'
    'false': '0'
    value: '0'
  states: {}
- name: amp_p20
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,3,1,1
    label: Amplitud +20 MHz
    labels: '[''0.005'', ''0.01'', ''0.02'', ''0.05'', ''0.1'', ''0.2'', ''0.3'', ''0.4'', ''0.5'', ''0.6'', ''0.7'', ''0.8'', ''0.9'']'
    options: '[0.005, 0.01, 0.02, 0.05, 0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7, 0.8, 0.9]'
    num_opts: '0'
    type: real
    value: '0.5'
    widget: radio_buttons
  states: {}
- name: fase_p20
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,3,1,1
    label: Fase
    min_len: '160'
    orient: QtCore.Qt.Vertical
    start: '-180'
    step: '1'
    stop: '180'
    value: '0'
    widget: slider
  states: {}
- name: et_suma
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.3f'' % x'
    gui_hint: 2,0,1,2
    label: 'Suma de amplitudes: '
    type: real
    value: suma
  states: {}
- name: et_escala
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''x1 (sin cambios)'' if x >= 1 else (''x%.2f (REDUCIDA)'' % x)'
    gui_hint: 2,2,1,2
    label: 'Escala aplicada: '
    type: real
    value: escala
  states: {}
- name: sale_m20
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 3,0,1,1
    label: '-20 MHz sale en '
    type: real
    value: (freq + (-20000000)) / 1e6
  states: {}
- name: lee_m20
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%+.0f grados'' % x'
    gui_hint: 7,0,1,1
    label: 'Fase -20 MHz: '
    type: real
    value: fase_m20
  states: {}
- name: sale_m10
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 3,1,1,1
    label: '-10 MHz sale en '
    type: real
    value: (freq + (-10000000)) / 1e6
  states: {}
- name: lee_m10
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%+.0f grados'' % x'
    gui_hint: 7,1,1,1
    label: 'Fase -10 MHz: '
    type: real
    value: fase_m10
  states: {}
- name: sale_p10
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 3,2,1,1
    label: '+10 MHz sale en '
    type: real
    value: (freq + (10000000)) / 1e6
  states: {}
- name: lee_p10
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%+.0f grados'' % x'
    gui_hint: 7,2,1,1
    label: 'Fase +10 MHz: '
    type: real
    value: fase_p10
  states: {}
- name: sale_p20
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 3,3,1,1
    label: '+20 MHz sale en '
    type: real
    value: (freq + (20000000)) / 1e6
  states: {}
- name: lee_p20
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%+.0f grados'' % x'
    gui_hint: 7,3,1,1
    label: 'Fase +20 MHz: '
    type: real
    value: fase_p20
  states: {}
- name: suma
  id: variable
  parameters:
    comment: Suma de las amplitudes habilitadas
    value: hab_m20*amp_m20 + hab_m10*amp_m10 + hab_p10*amp_p10 + hab_p20*amp_p20
  states: {}
- name: escala
  id: variable
  parameters:
    comment: Factor comun que evita el desborde
    value: min(1.0, suma_max / suma) if suma > 0 else 1.0
  states: {}
- name: aspecto
  id: snippet
  parameters:
    comment: Letra grande en las etiquetas de estado
    section: main_after_init
    code: |
      # Las etiquetas de GNU Radio no tienen tamano de letra: se lo cambiamos aca.
      for nombre in ('et_suma', 'et_escala'):
          barra = getattr(self, '_%s_tool_bar' % nombre)
          ancho = 120
          for accion in barra.actions():
              etiqueta = barra.widgetForAction(accion)
              etiqueta.setStyleSheet('font-size: 15pt; font-weight: bold')
              ancho += etiqueta.sizeHint().width()
          barra.setMinimumWidth(ancho)
      # Los deslizadores verticales de fase necesitan altura para moverlos con precision.
      for tono in ('m20', 'm10', 'p10', 'p20'):
          getattr(self, '_fase_%s_win' % tono).setMinimumHeight(200)
      self.resize(self.top_widget.minimumSizeHint().width() + 60,
                  self.top_widget.minimumSizeHint().height() + 70)
  states: {}
- name: k_m20
  id: variable
  parameters:
    comment: Amplitud y fase del tono de -20 MHz
    value: hab_m20 * amp_m20 * escala * np.exp(1j*np.deg2rad(fase_m20))
  states: {}
- name: k_m10
  id: variable
  parameters:
    comment: Amplitud y fase del tono de -10 MHz
    value: hab_m10 * amp_m10 * escala * np.exp(1j*np.deg2rad(fase_m10))
  states: {}
- name: k_p10
  id: variable
  parameters:
    comment: Amplitud y fase del tono de +10 MHz
    value: hab_p10 * amp_p10 * escala * np.exp(1j*np.deg2rad(fase_p10))
  states: {}
- name: k_p20
  id: variable
  parameters:
    comment: Amplitud y fase del tono de +20 MHz
    value: hab_p20 * amp_p20 * escala * np.exp(1j*np.deg2rad(fase_p20))
  states: {}
- name: fuente_m20
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-20000000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: mult_m20
  id: blocks_multiply_const_vxx
  parameters:
    const: k_m20
    type: complex
  states: {}
- name: fuente_m10
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-10000000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: mult_m10
  id: blocks_multiply_const_vxx
  parameters:
    const: k_m10
    type: complex
  states: {}
- name: fuente_p10
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: mult_p10
  id: blocks_multiply_const_vxx
  parameters:
    const: k_p10
    type: complex
  states: {}
- name: fuente_p20
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '20000000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: mult_p20
  id: blocks_multiply_const_vxx
  parameters:
    const: k_p20
    type: complex
  states: {}
- name: suma_tonos
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=321e0fa5875945d99b11070bb0a76d31
    bb_gain0: '0'
    bw0: ancho_banda
    freq0: freq
    gain0: tx_gain
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [fuente_m20, '0', mult_m20, '0']
- [mult_m20, '0', suma_tonos, '0']
- [fuente_m10, '0', mult_m10, '0']
- [mult_m10, '0', suma_tonos, '1']
- [fuente_p10, '0', mult_p10, '0']
- [mult_p10, '0', suma_tonos, '2']
- [fuente_p20, '0', mult_p20, '0']
- [mult_p20, '0', suma_tonos, '3']
- [suma_tonos, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
