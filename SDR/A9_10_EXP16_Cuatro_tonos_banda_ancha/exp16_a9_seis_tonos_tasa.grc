options:
  parameters:
    description: 'bladeRF 2.0 micro xA9: seis tonos en +/-5, +/-10 y +/-20 MHz con habilitacion y amplitud propias, y selector de tasa de muestreo para encontrar la maxima sin cortes'
    generate_options: qt_gui
    id: exp16_a9_seis_tonos_tasa
    output_language: python
    title: 'EXP-16 xA9: seis tonos y tasa de muestreo'
  states: {}

blocks:
- name: suma_max
  id: variable
  parameters:
    comment: La suma de amplitudes nunca pasa de este valor (evita el desborde)
    value: '0.95'
  states: {}
- name: fraccion_util
  id: variable
  parameters:
    comment: Un tono entra si su frecuencia no supera esta fraccion de la tasa de muestreo
    value: '0.4'
  states: {}
- name: ancho_banda
  id: variable
  parameters:
    comment: Filtro analogico de la placa, segun la tasa
    value: min(0.9 * samp_rate, 56e6)
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,6
    label: Portadora
    labels: '[''100 MHz'', ''500 MHz'', ''1 GHz'', ''1,5 GHz'', ''2 GHz'', ''3 GHz'', ''4 GHz'', ''5 GHz'']'
    options: '[100000000, 500000000, 1000000000, 1500000000, 2000000000, 3000000000, 4000000000, 5000000000]'
    num_opts: '0'
    orient: Qt.QHBoxLayout
    type: real
    value: '100000000'
    widget: radio_buttons
  states: {}
- name: tx_gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,6
    label: Ganancia de transmision (dB)
    labels: '[''0 dB'', ''15 dB'', ''30 dB'', ''45 dB'', ''55 dB'', ''60 dB'']'
    options: '[0, 15, 30, 45, 55, 60]'
    num_opts: '0'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0,1,6
    label: Tasa de muestreo
    labels: '[''15 MSPS'', ''20 MSPS'', ''25 MSPS'', ''30 MSPS'', ''40 MSPS'', ''50 MSPS'']'
    options: '[15e6, 20e6, 25e6, 30e6, 40e6, 50e6]'
    num_opts: '0'
    orient: Qt.QHBoxLayout
    type: real
    value: 25e6
    widget: radio_buttons
  states: {}
- name: hab_m20
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 5,0,1,1
    label: Habilitar -20 MHz
    type: int
    'true': '1'
    'false': '0'
    value: '0'
  states: {}
- name: amp_m20
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 7,0,1,1
    label: Amplitud -20 MHz
    labels: '[''0.005'', ''0.01'', ''0.02'', ''0.05'', ''0.1'', ''0.2'', ''0.3'', ''0.4'', ''0.5'', ''0.6'', ''0.7'', ''0.8'', ''0.9'']'
    options: '[0.005, 0.01, 0.02, 0.05, 0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7, 0.8, 0.9]'
    num_opts: '0'
    type: real
    value: '0.5'
    widget: radio_buttons
  states: {}
- name: hab_m10
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 5,1,1,1
    label: Habilitar -10 MHz
    type: int
    'true': '1'
    'false': '0'
    value: '0'
  states: {}
- name: amp_m10
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 7,1,1,1
    label: Amplitud -10 MHz
    labels: '[''0.005'', ''0.01'', ''0.02'', ''0.05'', ''0.1'', ''0.2'', ''0.3'', ''0.4'', ''0.5'', ''0.6'', ''0.7'', ''0.8'', ''0.9'']'
    options: '[0.005, 0.01, 0.02, 0.05, 0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7, 0.8, 0.9]'
    num_opts: '0'
    type: real
    value: '0.5'
    widget: radio_buttons
  states: {}
- name: hab_m5
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 5,2,1,1
    label: Habilitar -5 MHz
    type: int
    'true': '1'
    'false': '0'
    value: '0'
  states: {}
- name: amp_m5
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 7,2,1,1
    label: Amplitud -5 MHz
    labels: '[''0.005'', ''0.01'', ''0.02'', ''0.05'', ''0.1'', ''0.2'', ''0.3'', ''0.4'', ''0.5'', ''0.6'', ''0.7'', ''0.8'', ''0.9'']'
    options: '[0.005, 0.01, 0.02, 0.05, 0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7, 0.8, 0.9]'
    num_opts: '0'
    type: real
    value: '0.5'
    widget: radio_buttons
  states: {}
- name: hab_p5
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 5,3,1,1
    label: Habilitar +5 MHz
    type: int
    'true': '1'
    'false': '0'
    value: '0'
  states: {}
- name: amp_p5
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 7,3,1,1
    label: Amplitud +5 MHz
    labels: '[''0.005'', ''0.01'', ''0.02'', ''0.05'', ''0.1'', ''0.2'', ''0.3'', ''0.4'', ''0.5'', ''0.6'', ''0.7'', ''0.8'', ''0.9'']'
    options: '[0.005, 0.01, 0.02, 0.05, 0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7, 0.8, 0.9]'
    num_opts: '0'
    type: real
    value: '0.5'
    widget: radio_buttons
  states: {}
- name: hab_p10
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 5,4,1,1
    label: Habilitar +10 MHz
    type: int
    'true': '1'
    'false': '0'
    value: '1'
  states: {}
- name: amp_p10
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 7,4,1,1
    label: Amplitud +10 MHz
    labels: '[''0.005'', ''0.01'', ''0.02'', ''0.05'', ''0.1'', ''0.2'', ''0.3'', ''0.4'', ''0.5'', ''0.6'', ''0.7'', ''0.8'', ''0.9'']'
    options: '[0.005, 0.01, 0.02, 0.05, 0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7, 0.8, 0.9]'
    num_opts: '0'
    type: real
    value: '0.5'
    widget: radio_buttons
  states: {}
- name: hab_p20
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 5,5,1,1
    label: Habilitar +20 MHz
    type: int
    'true': '1'
    'false': '0'
    value: '0'
  states: {}
- name: amp_p20
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 7,5,1,1
    label: Amplitud +20 MHz
    labels: '[''0.005'', ''0.01'', ''0.02'', ''0.05'', ''0.1'', ''0.2'', ''0.3'', ''0.4'', ''0.5'', ''0.6'', ''0.7'', ''0.8'', ''0.9'']'
    options: '[0.005, 0.01, 0.02, 0.05, 0.1, 0.2, 0.3, 0.4, 0.5, 0.6, 0.7, 0.8, 0.9]'
    num_opts: '0'
    type: real
    value: '0.5'
    widget: radio_buttons
  states: {}
- name: et_suma
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.3f'' % x'
    gui_hint: 3,0,1,3
    label: 'Suma de amplitudes: '
    type: real
    value: suma
  states: {}
- name: et_escala
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''x1 (sin cambios)'' if x >= 1 else (''x%.2f (REDUCIDA)'' % x)'
    gui_hint: 3,3,1,3
    label: 'Escala aplicada: '
    type: real
    value: escala
  states: {}
- name: sale_m20
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 4,0,1,1
    label: '-20 MHz sale en '
    type: real
    value: (freq + (-20000000)) / 1e6
  states: {}
- name: est_m20
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''disponible'' if x else ''NO ENTRA con esta tasa'''
    gui_hint: 6,0,1,1
    label: ' '
    type: real
    value: cabe_m20
  states: {}
- name: sale_m10
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 4,1,1,1
    label: '-10 MHz sale en '
    type: real
    value: (freq + (-10000000)) / 1e6
  states: {}
- name: est_m10
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''disponible'' if x else ''NO ENTRA con esta tasa'''
    gui_hint: 6,1,1,1
    label: ' '
    type: real
    value: cabe_m10
  states: {}
- name: sale_m5
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 4,2,1,1
    label: '-5 MHz sale en '
    type: real
    value: (freq + (-5000000)) / 1e6
  states: {}
- name: est_m5
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''disponible'' if x else ''NO ENTRA con esta tasa'''
    gui_hint: 6,2,1,1
    label: ' '
    type: real
    value: cabe_m5
  states: {}
- name: sale_p5
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 4,3,1,1
    label: '+5 MHz sale en '
    type: real
    value: (freq + (5000000)) / 1e6
  states: {}
- name: est_p5
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''disponible'' if x else ''NO ENTRA con esta tasa'''
    gui_hint: 6,3,1,1
    label: ' '
    type: real
    value: cabe_p5
  states: {}
- name: sale_p10
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 4,4,1,1
    label: '+10 MHz sale en '
    type: real
    value: (freq + (10000000)) / 1e6
  states: {}
- name: est_p10
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''disponible'' if x else ''NO ENTRA con esta tasa'''
    gui_hint: 6,4,1,1
    label: ' '
    type: real
    value: cabe_p10
  states: {}
- name: sale_p20
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.0f MHz'' % x'
    gui_hint: 4,5,1,1
    label: '+20 MHz sale en '
    type: real
    value: (freq + (20000000)) / 1e6
  states: {}
- name: est_p20
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''disponible'' if x else ''NO ENTRA con esta tasa'''
    gui_hint: 6,5,1,1
    label: ' '
    type: real
    value: cabe_p20
  states: {}
- name: cabe_m20
  id: variable
  parameters:
    comment: 1 si el tono de -20 MHz entra en la tasa elegida
    value: 1 if 20000000 <= fraccion_util * samp_rate else 0
  states: {}
- name: act_m20
  id: variable
  parameters:
    comment: Tono de -20 MHz activo
    value: hab_m20 * cabe_m20
  states: {}
- name: k_m20
  id: variable
  parameters:
    comment: Amplitud final del tono de -20 MHz
    value: act_m20 * amp_m20 * escala
  states: {}
- name: cabe_m10
  id: variable
  parameters:
    comment: 1 si el tono de -10 MHz entra en la tasa elegida
    value: 1 if 10000000 <= fraccion_util * samp_rate else 0
  states: {}
- name: act_m10
  id: variable
  parameters:
    comment: Tono de -10 MHz activo
    value: hab_m10 * cabe_m10
  states: {}
- name: k_m10
  id: variable
  parameters:
    comment: Amplitud final del tono de -10 MHz
    value: act_m10 * amp_m10 * escala
  states: {}
- name: cabe_m5
  id: variable
  parameters:
    comment: 1 si el tono de -5 MHz entra en la tasa elegida
    value: 1 if 5000000 <= fraccion_util * samp_rate else 0
  states: {}
- name: act_m5
  id: variable
  parameters:
    comment: Tono de -5 MHz activo
    value: hab_m5 * cabe_m5
  states: {}
- name: k_m5
  id: variable
  parameters:
    comment: Amplitud final del tono de -5 MHz
    value: act_m5 * amp_m5 * escala
  states: {}
- name: cabe_p5
  id: variable
  parameters:
    comment: 1 si el tono de +5 MHz entra en la tasa elegida
    value: 1 if 5000000 <= fraccion_util * samp_rate else 0
  states: {}
- name: act_p5
  id: variable
  parameters:
    comment: Tono de +5 MHz activo
    value: hab_p5 * cabe_p5
  states: {}
- name: k_p5
  id: variable
  parameters:
    comment: Amplitud final del tono de +5 MHz
    value: act_p5 * amp_p5 * escala
  states: {}
- name: cabe_p10
  id: variable
  parameters:
    comment: 1 si el tono de +10 MHz entra en la tasa elegida
    value: 1 if 10000000 <= fraccion_util * samp_rate else 0
  states: {}
- name: act_p10
  id: variable
  parameters:
    comment: Tono de +10 MHz activo
    value: hab_p10 * cabe_p10
  states: {}
- name: k_p10
  id: variable
  parameters:
    comment: Amplitud final del tono de +10 MHz
    value: act_p10 * amp_p10 * escala
  states: {}
- name: cabe_p20
  id: variable
  parameters:
    comment: 1 si el tono de +20 MHz entra en la tasa elegida
    value: 1 if 20000000 <= fraccion_util * samp_rate else 0
  states: {}
- name: act_p20
  id: variable
  parameters:
    comment: Tono de +20 MHz activo
    value: hab_p20 * cabe_p20
  states: {}
- name: k_p20
  id: variable
  parameters:
    comment: Amplitud final del tono de +20 MHz
    value: act_p20 * amp_p20 * escala
  states: {}
- name: suma
  id: variable
  parameters:
    comment: Suma de las amplitudes activas
    value: act_m20*amp_m20 + act_m10*amp_m10 + act_m5*amp_m5 + act_p5*amp_p5 + act_p10*amp_p10 + act_p20*amp_p20
  states: {}
- name: escala
  id: variable
  parameters:
    comment: Factor comun que evita el desborde
    value: min(1.0, suma_max / suma) if suma > 0 else 1.0
  states: {}
- name: aspecto
  id: snippet
  parameters:
    comment: Letra grande, y controles en gris cuando un tono no entra en la tasa
    section: main_after_init
    code: |
      # Ajustes de aspecto que los bloques de GNU Radio no permiten configurar.
      # 1) Etiquetas de estado con letra grande.
      for nombre in ('et_suma', 'et_escala'):
          barra = getattr(self, '_%s_tool_bar' % nombre)
          ancho = 120
          for accion in barra.actions():
              etiqueta = barra.widgetForAction(accion)
              etiqueta.setStyleSheet('font-size: 15pt; font-weight: bold')
              ancho += etiqueta.sizeHint().width()
          barra.setMinimumWidth(ancho)

      # 2) Si un tono no entra en la tasa elegida, su casilla y su amplitud quedan en gris y no se pueden tocar.
      #    (El flujo igual lo deja apagado por su cuenta: esto es solo para que se vea.)
      tonos = ('m20', 'm10', 'm5', 'p5', 'p10', 'p20')
      def actualizar_disponibles():
          for columna, t in enumerate(tonos):
              entra = bool(getattr(self, 'cabe_' + t))
              self.top_grid_layout.itemAtPosition(5, columna).widget().setEnabled(entra)   # casilla de habilitar
              getattr(self, '_amp_%s_group_box' % t).setEnabled(entra)                     # botones de amplitud
      cambiar_tasa = self.set_samp_rate
      def cambiar_tasa_y_actualizar(valor):
          cambiar_tasa(valor)
          actualizar_disponibles()
      self.set_samp_rate = cambiar_tasa_y_actualizar
      actualizar_disponibles()

      # 3) Tamano inicial de la ventana segun su contenido.
      self.resize(self.top_widget.minimumSizeHint().width() + 60, self.top_widget.minimumSizeHint().height() + 70)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: n_tabla
  id: variable
  parameters:
    comment: 'Indices de la tabla: 1000 periodos de 5 MHz'
    value: np.arange(int(round(samp_rate / 5e6)) * 1000)
  states: {}
- name: tabla
  id: variable
  parameters:
    comment: Suma de los seis tonos, lista para repetir
    value: (k_m20*np.exp(2j*np.pi*(-20000000)*n_tabla/samp_rate) + k_m10*np.exp(2j*np.pi*(-10000000)*n_tabla/samp_rate) + k_m5*np.exp(2j*np.pi*(-5000000)*n_tabla/samp_rate) + k_p5*np.exp(2j*np.pi*(5000000)*n_tabla/samp_rate) + k_p10*np.exp(2j*np.pi*(10000000)*n_tabla/samp_rate) + k_p20*np.exp(2j*np.pi*(20000000)*n_tabla/samp_rate) + 0j*n_tabla).tolist()
  states: {}
- name: fuente_tabla
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: tabla
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=321e0fa5875945d99b11070bb0a76d31
    bb_gain0: '0'
    bw0: ancho_banda
    freq0: freq
    gain0: tx_gain
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [fuente_tabla, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
