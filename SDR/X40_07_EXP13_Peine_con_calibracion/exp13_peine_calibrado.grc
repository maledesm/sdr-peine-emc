options:
  parameters:
    description: 'Igual al EXP-12, mas un Python Snippet que antes de abrir la placa llama a bladeRF-cli: calibrate lms y tabla de correccion de la fuga de portadora por frecuencia'
    generate_options: qt_gui
    id: exp13_peine_calibrado
    output_language: python
    title: EXP-13 peine de 8 tonos con calibracion de la placa
  states: {}

blocks:
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Tasa de muestreo. Requiere USB 3
    value: 20e6
  states: {}
- name: f_tono
  id: variable
  parameters:
    comment: Los dos tonos van en +f_tono y -f_tono
    value: 5e6
  states: {}
- name: tasa_ctrl
  id: variable
  parameters:
    comment: Tasa de la rama de control del barrido
    value: 10e3
  states: {}
- name: portadoras
  id: variable
  parameters:
    comment: 4 portadoras, de 305 a 365 MHz
    value: '[305e6 + 20e6*i for i in range(4)]'
  states: {}
- name: modo
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Modo
    num_opts: '2'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
    option0: '0'
    label0: Automatico
    option1: '1'
    label1: Manual
  states: {}
- name: portadora_manual
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: Portadora en modo manual
    labels: '[''305 MHz'', ''325 MHz'', ''345 MHz'', ''365 MHz'']'
    options: '[305000000, 325000000, 345000000, 365000000]'
    num_opts: '0'
    type: real
    value: '305000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label: Ganancia TX (dB)
    num_opts: '4'
    orient: Qt.QHBoxLayout
    type: real
    value: '30'
    widget: radio_buttons
    option0: '17'
    label0: '17'
    option1: '20'
    label1: '20'
    option2: '25'
    label2: '25'
    option3: '30'
    label3: '30'
  states: {}
- name: permanencia
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Permanencia por portadora (s)
    min_len: '250'
    start: '1'
    step: '0.5'
    stop: '20'
    value: '2'
  states: {}
- name: amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Amplitud de cada tono
    min_len: '250'
    start: '0.05'
    step: '0.01'
    stop: '0.45'
    value: '0.4'
  states: {}
- name: fase_inf
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Fase del tono inferior (grados)
    min_len: '250'
    start: '-180'
    step: '1'
    stop: '180'
    value: '0'
  states: {}
- name: et_portadora
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,1
    label: Portadora actual (MHz)
    type: real
    value: freq / 1e6
  states: {}
- name: et_inferior
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,1,1,1
    label: Linea inferior (MHz)
    type: real
    value: (freq - f_tono) / 1e6
  states: {}
- name: et_superior
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,2,1,1
    label: Linea superior (MHz)
    type: real
    value: (freq + f_tono) / 1e6
  states: {}
- name: et_paso
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,0,1,1
    label: Paso del barrido (1 a 4)
    type: real
    value: indice + 1
  states: {}
- name: et_pico
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,1,1,1
    label: Pico de banda base (debe ser < 1)
    type: real
    value: 2 * amp
  states: {}
- name: indice_medido
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    comment: Lee la escalera de la rama de control
    function_name: level
    poll_rate: '2'
    value: '0'
  states: {}
- name: indice
  id: variable
  parameters:
    comment: Numero de portadora, desde 0
    value: min(max(int(round(indice_medido)), 0), len(portadoras) - 1)
  states: {}
- name: freq
  id: variable
  parameters:
    comment: Frecuencia del oscilador
    value: portadora_manual if modo == 1 else portadoras[indice]
  states: {}
- name: c_inf
  id: variable
  parameters:
    comment: Fase aplicada al tono inferior
    value: np.exp(1j*np.deg2rad(fase_inf))
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: f_tono
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_inf
  id: blocks_multiply_const_vxx
  parameters:
    const: c_inf
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=0
    bb_gain0: '0'
    bw0: 14e6
    freq0: freq
    gain0: tx_gain
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: list(range(len(portadoras)))
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(permanencia * tasa_ctrl)
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '0.05'
    samples_per_second: tasa_ctrl
    type: float
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: calibrar_lms
  id: variable
  parameters:
    comment: 'True: corre calibrate lms al arrancar'
    value: 'True'
  states: {}
- name: generar_tabla
  id: variable
  parameters:
    comment: 'True: genera la tabla de fuga (tarda). False: usa la que ya exista'
    value: 'True'
  states: {}
- name: usar_tabla
  id: variable
  parameters:
    comment: 'False: desactiva la tabla, para comparar sin correccion'
    value: 'True'
  states: {}
- name: ganancia_tabla
  id: variable
  parameters:
    comment: Ganancia con la que se genera la tabla. Tiene que ser la del peine
    value: '30'
  states: {}
- name: calibracion
  id: snippet
  parameters:
    comment: Calibra la placa con bladeRF-cli antes de abrirla
    code: |
      # Corre ANTES de que el osmocom Sink abra la placa, cuando todavia esta libre.
      import os, shutil, subprocess, time

      cli = r"C:\Program Files\bladeRF\x64\bladeRF-cli.exe"
      carpeta = os.path.dirname(os.path.abspath(__file__))
      destino = os.path.join(os.environ["APPDATA"], "Nuand", "bladeRF")   # donde la biblioteca busca las tablas

      def correr(comandos):
          """Ejecuta comandos de bladeRF-cli, muestra la salida en la consola y la devuelve."""
          args = [cli]
          for c in comandos:
              args += ["-e", c]
          p = subprocess.Popen(args, cwd=carpeta, stdout=subprocess.PIPE, stderr=subprocess.STDOUT, text=True)
          salida = []
          for linea in p.stdout:
              print("   [bladeRF-cli] " + linea.rstrip())
              salida.append(linea)
          p.wait()
          return "".join(salida)

      def tablas(sufijo):
          return [f for f in os.listdir(destino) if f.endswith("_dc_tx" + sufijo)] if os.path.isdir(destino) else []

      print("=== EXP-13: calibracion antes de transmitir ===")
      t_inicio = time.time()

      if self.calibrar_lms:
          print("1) calibrate lms")
          correr(["calibrate lms"])
          print("   Lectura en una apertura nueva (si no son todos 31, la calibracion sobrevive al cierre):")
          correr(["calibrate lms show"])

      if self.generar_tabla:
          print("2) Generando la tabla de fuga para las portadoras del peine. Puede tardar varios minutos.")
          for f in os.listdir(carpeta):          # borrar tablas de corridas anteriores
              if f.endswith("_dc_tx.tbl"):
                  os.remove(os.path.join(carpeta, f))
          f_min = "%dM" % round(min(self.portadoras) / 1e6)
          f_max = "%dM" % round(max(self.portadoras) / 1e6)
          salida = correr(["set gain tx1 %d" % self.ganancia_tabla,
                           "print gain",
                           "calibrate table dc tx %s %s 20M" % (f_min, f_max)])
          nuevas = [f for f in os.listdir(carpeta) if f.endswith("_dc_tx.tbl")]
          if nuevas:
              os.makedirs(destino, exist_ok=True)
              for f in nuevas:
                  shutil.copyfile(os.path.join(carpeta, f), os.path.join(destino, f))
                  print("   Tabla instalada: " + os.path.join(destino, f))
          else:
              print("   ATENCION: no se genero ninguna tabla. Revisar los mensajes de arriba.")

      # activar o desactivar la tabla instalada, para comparar con y sin correccion
      if self.usar_tabla:
          for f in tablas(".tbl.desactivada"):
              os.replace(os.path.join(destino, f), os.path.join(destino, f[:-len(".desactivada")]))
          print("3) Tabla de fuga ACTIVADA: " + (", ".join(tablas(".tbl")) or "no hay ninguna instalada"))
      else:
          for f in tablas(".tbl"):
              os.replace(os.path.join(destino, f), os.path.join(destino, f + ".desactivada"))
          print("3) Tabla de fuga DESACTIVADA: la placa transmite sin correccion")
      print("=== Fin de la calibracion ===")

      # aviso sonoro y cartel: la transmision empieza recien al aceptar
      lineas = ["Calibracion terminada en %.0f segundos." % (time.time() - t_inicio), "",
                "calibrate lms: " + ("ejecutada" if self.calibrar_lms else "omitida"),
                "Tabla de fuga: " + ("generada" if self.generar_tabla else "no regenerada"),
                "Estado de la tabla: " + (("ACTIVADA (%s)" % (", ".join(tablas(".tbl")) or "no hay ninguna instalada"))
                                          if self.usar_tabla else "DESACTIVADA"), "",
                "Al aceptar se abre la placa y empieza a transmitir."]
      resumen = chr(10).join(lineas)
      try:
          import winsound
          for _ in range(3):
              winsound.Beep(1000, 250)
      except Exception:
          pass
      try:
          Qt.QMessageBox.information(None, "EXP-13: calibracion terminada", resumen)
      except Exception as e:
          print("No se pudo mostrar el cartel: %s" % e)
      print("=== Abriendo la placa para transmitir ===")
    section: init_before_blocks
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_const_inf, '0']
- [blocks_multiply_const_inf, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_probe_signal_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
